Properties of the parts of a building model (IFC2X3), part 12 of 29

# IfcFlowFitting: Transition - Generic (1079)
Name (M_Transition - Generic:Transition - Generic:Transition - Generic:...) | In | Fitting Outside Radius 1 = Insulation Radius 1 | Width Offset | Visibility 3 | Visibility 1 | Max Fitting Outside Diameter 12 | Visibility 2 | Fitting Outside Radius 2 = Insulation Radius 2 | Height Offset | System Name | System Classification | System Type | Loss Method | Offset (mm) | Level | Host | Mark | Fitting Outside Diameter 2 | OffsetHeight | Length | Nominal Radius 1 | OffsetWidth | Nominal Radius 2 | Tick Size 2 | Tick Size 1 | Fitting Outside Diameter 1 | Size = Overall Size | Nominal Diameter 1 | Nominal Diameter 2
645545 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -461.436 | Level: Level 1 | Level : Level 1 | 2919 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
645709 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 9.96894 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -461.436 | Level: Level 1 | Level : Level 1 | 2944 | 0.114583 | 0.0509581 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
645741 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -501.123 | Level: Level 1 | Level : Level 1 | 2946 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
645817 | TOF Footing | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -447.612 | Level: Level 1 | Level : Level 1 | 2961 | 0.114583 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.0524934 | 0.0458333 | 0.104167 | 0.260417 | 80 mmø-32 mmø | 0.262467 | 0.104987
645870 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -434.912 | Level: Level 1 | Level : Level 1 | 2983 | 0.114583 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0524934 | 0.0458333 | 0.1375 | 0.34375 | 100 mmø-32 mmø | 0.328084 | 0.104987
645957 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -460.312 | Level: Level 1 | Level : Level 1 | 2996 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
646050 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -434.912 | Level: Level 1 | Level : Level 1 | 3004 | 0.114583 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0524934 | 0.0458333 | 0.1375 | 0.34375 | 100 mmø-32 mmø | 0.328084 | 0.104987
646099 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -434.913 | Level: Level 1 | Level : Level 1 | 3010 | 0.114583 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0524934 | 0.0458333 | 0.1375 | 0.34375 | 100 mmø-32 mmø | 0.328084 | 0.104987
646203 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -461.436 | Level: Level 1 | Level : Level 1 | 3040 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
646273 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -461.436 | Level: Level 1 | Level : Level 1 | 3050 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
646388 | TOF Footing | 0.0885417 | 9.98432 | no | no | 0.177083 | yes | 0.0572917 | 10.0169 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -461.397 | Level: Level 1 | Level : Level 1 | 3065 | 0.114583 | 0.0988999 | 0.0442708 | 0.082021 | 0.0663448 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
646398 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -501.123 | Level: Level 1 | Level : Level 1 | 3067 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
646433 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -461.436 | Level: Level 1 | Level : Level 1 | 3081 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
646728 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10.0037 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -501.123 | Level: Level 1 | Level : Level 1 | 3120 | 0.177083 | 0.167728 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
646922 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -500 | Level: Level 1 | Level : Level 1 | 3136 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
647040 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10.0037 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -501.123 | Level: Level 1 | Level : Level 1 | 3151 | 0.177083 | 0.167728 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
647249 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -500 | Level: Level 1 | Level : Level 1 | 3170 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
647271 | Level 1 | 0.0677083 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 2900 | Level: Level 1 | Level : Level 1 | 3174 | 0.177083 | 0.0656168 | 0.0442708 | 0.0656168 | 0.0656168 | 0.082021 | 0.0708333 | 0.0541667 | 0.135417 | 50 mmø-40 mmø | 0.131234 | 0.164042
647523 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -500 | Level: Level 1 | Level : Level 1 | 3204 | 0.114583 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0524934 | 0.0458333 | 0.1375 | 0.34375 | 100 mmø-32 mmø | 0.328084 | 0.104987
647577 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 298.02 | Level: Level 1 | Level : Level 1 | 3208 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
647708 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 39.6875 | Level: Level 1 | Level : Level 1 | 3223 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
647709 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -39.6875 | Level: Level 1 | Level : Level 1 | 3224 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
647788 | Level 1 | 0.0885417 | 10.0081 | no | yes | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 1000 | Level: Level 1 | Level : Level 1 | 3234 | 0.177083 | 0.082021 | 0.0442708 | 0.082021 | 0.0900747 | 0.082021 | 0.0708333 | 0.0708333 | 0.177083 | 50 mmø-50 mmø | 0.164042 | 0.164042
647821 | Level 1 | 0.0572917 | 10 | yes | no | 0.135417 | no | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 0 | Level: Level 1 | Level : Level 1 | 3236 | 0.135417 | 0.0524934 | 0.0338542 | 0.0524934 | 0.0524934 | 0.0656168 | 0.0541667 | 0.0458333 | 0.114583 | 40 mmø-32 mmø | 0.104987 | 0.131234
648100 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 33.3375 | Level: Level 1 | Level : Level 1 | 3251 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
648101 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -33.3375 | Level: Level 1 | Level : Level 1 | 3252 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
648294 | Level 1 | 0.0572917 | 9.98588 | no | yes | 0.114583 | no | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 0 | Level: Level 1 | Level : Level 1 | 3269 | 0.114583 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0383751 | 0.0524934 | 0.0458333 | 0.0458333 | 0.114583 | 32 mmø-32 mmø | 0.104987 | 0.104987
654014 | Level 1 | 0.0572917 | 10 | yes | no | 0.135417 | no | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -411 | Level: Level 2 | Level : Level 2 | 3312 | 0.135417 | 0.0524934 | 0.0338542 | 0.0524934 | 0.0524934 | 0.0656168 | 0.0541667 | 0.0458333 | 0.114583 | 40 mmø-32 mmø | 0.104987 | 0.131234
654024 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -411 | Level: Level 2 | Level : Level 2 | 3317 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
654323 | Level 1 | 0.0572917 | 10 | yes | no | 0.260417 | no | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -411 | Level: Level 2 | Level : Level 2 | 3347 | 0.260417 | 0.0524934 | 0.0651042 | 0.0524934 | 0.0524934 | 0.131234 | 0.104167 | 0.0458333 | 0.114583 | 80 mmø-32 mmø | 0.104987 | 0.262467
654328 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -411 | Level: Level 2 | Level : Level 2 | 3351 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
654615 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -411 | Level: Level 2 | Level : Level 2 | 3367 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
655107 | Level 1 | 0.0885417 | 10 | yes | no | 0.34375 | no | 0.171875 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 0 | Level: Level 1 | Level : Level 1 | 3396 | 0.34375 | 0.082021 | 0.0859375 | 0.082021 | 0.082021 | 0.164042 | 0.1375 | 0.0708333 | 0.177083 | 100 mmø-50 mmø | 0.164042 | 0.328084
655123 | Level 1 | 0.0572917 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 0 | Level: Level 1 | Level : Level 1 | 3402 | 0.177083 | 0.0524934 | 0.0442708 | 0.0524934 | 0.0524934 | 0.082021 | 0.0708333 | 0.0458333 | 0.114583 | 50 mmø-32 mmø | 0.104987 | 0.164042
655128 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 0 | Level: Level 1 | Level : Level 1 | 3406 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
655498 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -345.912 | Level: Level 2 | Level : Level 2 | 3441 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
655505 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -200 | Level: Level 2 | Level : Level 2 | 3447 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
655525 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -200 | Level: Level 2 | Level : Level 2 | 3457 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
655530 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -200 | Level: Level 2 | Level : Level 2 | 3461 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
655603 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -345.912 | Level: Level 2 | Level : Level 2 | 3465 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
655610 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -200 | Level: Level 2 | Level : Level 2 | 3471 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
655916 | Level 1 | 0.171875 | 9.97272 | no | yes | 0.34375 | no | 0.171875 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 3487 | 0.34375 | 0.164042 | 0.0859375 | 0.164042 | 0.136761 | 0.164042 | 0.1375 | 0.1375 | 0.34375 | 100 mmø-100 mmø | 0.328084 | 0.328084
655933 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 3494 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
655944 | Level 1 | 0.0572917 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 3497 | 0.177083 | 0.0524934 | 0.0442708 | 0.0524934 | 0.0524934 | 0.082021 | 0.0708333 | 0.0458333 | 0.114583 | 50 mmø-32 mmø | 0.104987 | 0.164042
656246 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -500 | Level: Level 1 | Level : Level 1 | 3519 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
656396 | Level 1 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 400 | Level: Level 1 | Level : Level 1 | 3531 | 0.114583 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.0524934 | 0.0458333 | 0.104167 | 0.260417 | 80 mmø-32 mmø | 0.262467 | 0.104987
656452 | TOF Footing | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -447.612 | Level: Level 1 | Level : Level 1 | 3537 | 0.114583 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.0524934 | 0.0458333 | 0.104167 | 0.260417 | 80 mmø-32 mmø | 0.262467 | 0.104987
656523 | Level 1 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 2856.34 | Level: Level 1 | Level : Level 1 | 3551 | 0.114583 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.0524934 | 0.0458333 | 0.104167 | 0.260417 | 80 mmø-32 mmø | 0.262467 | 0.104987
656640 | Level 1 | 0.0572917 | 10 | yes | no | 0.135417 | no | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 2923.81 | Level: Level 1 | Level : Level 1 | 3559 | 0.135417 | 0.0524934 | 0.0338542 | 0.0524934 | 0.0524934 | 0.0656168 | 0.0541667 | 0.0458333 | 0.114583 | 40 mmø-32 mmø | 0.104987 | 0.131234
657002 | Level 1 | 0.130208 | 10 | yes | no | 0.34375 | no | 0.171875 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1728.24 | Level: Level 2 | Level : Level 2 | 3594 | 0.34375 | 0.131234 | 0.0859375 | 0.131234 | 0.131234 | 0.164042 | 0.1375 | 0.104167 | 0.260417 | 100 mmø-80 mmø | 0.262467 | 0.328084
657104 | Level 1 | 0.0885417 | 10 | yes | no | 0.260417 | no | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1682.2 | Level: Level 2 | Level : Level 2 | 3599 | 0.260417 | 0.082021 | 0.0651042 | 0.082021 | 0.082021 | 0.131234 | 0.104167 | 0.0708333 | 0.177083 | 80 mmø-50 mmø | 0.164042 | 0.262467
657195 | Level 1 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 9.99787 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1629.81 | Level: Level 2 | Level : Level 2 | 3613 | 0.177083 | 0.129105 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
657995 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1623.11 | Level: Level 2 | Level : Level 2 | 3652 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
658328 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1623.11 | Level: Level 2 | Level : Level 2 | 3682 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
658544 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1623.11 | Level: Level 2 | Level : Level 2 | 3715 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
658586 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 3723 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
659108 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 3772 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
659156 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 3784 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
659246 | Level 1 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 3797 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
659356 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 3805 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
659643 | Level 1 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 3823 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
659729 | Level 1 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 3833 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
660105 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 3886 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
660106 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 3887 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
660242 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 3892 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
660280 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 3901 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
660281 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 3902 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
660384 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 3914 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
660385 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 3915 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
660672 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 3943 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
660847 | Level 1 | 0.0677083 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 2973.01 | Level: Level 1 | Level : Level 1 | 3981 | 0.177083 | 0.0656168 | 0.0442708 | 0.0656168 | 0.0656168 | 0.082021 | 0.0708333 | 0.0541667 | 0.135417 | 50 mmø-40 mmø | 0.131234 | 0.164042
660881 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 3987 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
660945 | Level 1 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 3993 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
660993 | Level 2 | 0.0572917 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 4000 | 0.177083 | 0.0524934 | 0.0442708 | 0.0524934 | 0.0524934 | 0.082021 | 0.0708333 | 0.0458333 | 0.114583 | 50 mmø-32 mmø | 0.104987 | 0.164042
661114 | Level 2 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 500 | Level: Level 2 | Level : Level 2 | 4013 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
661158 | Level 1 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 4026 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
661482 | Level 1 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 4059 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
661640 | Level 1 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1635.81 | Level: Level 2 | Level : Level 2 | 4088 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
661868 | Level 1 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 4119 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
661953 | Level 1 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 4132 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
662075 | Level 1 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 4150 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
662128 | Level 1 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 4164 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
662268 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -460.312 | Level: Level 1 | Level : Level 1 | 4186 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
662521 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 4216 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
662522 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 4217 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
664146 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 4365 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
664317 | Level 1 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1635.81 | Level: Level 2 | Level : Level 2 | 4400 | 0.135417 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.0656168 | 0.0541667 | 0.104167 | 0.260417 | 80 mmø-40 mmø | 0.262467 | 0.131234
664336 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 4410 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
664487 | Level 2 | 0.0572917 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 4437 | 0.177083 | 0.0524934 | 0.0442708 | 0.0524934 | 0.0524934 | 0.082021 | 0.0708333 | 0.0458333 | 0.114583 | 50 mmø-32 mmø | 0.104987 | 0.164042
664529 | Level 2 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 500 | Level: Level 2 | Level : Level 2 | 4446 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
664969 | Level 2 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 298.02 | Level: Level 2 | Level : Level 2 | 4481 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
665093 | Level 2 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 298.02 | Level: Level 2 | Level : Level 2 | 4503 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
665182 | Level 1 | 0.0885417 | 10 | yes | no | 0.34375 | no | 0.171875 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 4517 | 0.34375 | 0.082021 | 0.0859375 | 0.082021 | 0.082021 | 0.164042 | 0.1375 | 0.0708333 | 0.177083 | 100 mmø-50 mmø | 0.164042 | 0.328084
665300 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1623.11 | Level: Level 2 | Level : Level 2 | 4535 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
665431 | Level 2 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 298.02 | Level: Level 2 | Level : Level 2 | 4546 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
665880 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 4566 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
666117 | Level 2 | 0.0572917 | 10.0106 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 4588 | 0.177083 | 0.0524934 | 0.0442708 | 0.0524934 | 0.0630666 | 0.082021 | 0.0708333 | 0.0458333 | 0.114583 | 50 mmø-32 mmø | 0.104987 | 0.164042
666136 | Level 2 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 239.688 | Level: Level 2 | Level : Level 2 | 4590 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
666178 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 4598 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
666200 | TOF Footing | 0.171875 | 10 | no | yes | 0.34375 | no | 0.171875 | 10.0037 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -501.123 | Level: Level 1 | Level : Level 1 | 4606 | 0.34375 | 0.167728 | 0.0859375 | 0.164042 | 0.164042 | 0.164042 | 0.1375 | 0.1375 | 0.34375 | 100 mmø-100 mmø | 0.328084 | 0.328084
666623 | Level 2 | 0.0572917 | 10 | yes | no | 0.34375 | no | 0.171875 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 4660 | 0.34375 | 0.0524934 | 0.0859375 | 0.0524934 | 0.0524934 | 0.164042 | 0.1375 | 0.0458333 | 0.114583 | 100 mmø-32 mmø | 0.104987 | 0.328084
666634 | Level 2 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 265.087 | Level: Level 2 | Level : Level 2 | 4662 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
666809 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1560 | Level: Level 2 | Level : Level 2 | 4697 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
666824 | Level 1 | 0.046875 | 10 | yes | no | 0.260417 | no | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1560 | Level: Level 2 | Level : Level 2 | 4703 | 0.260417 | 0.0410105 | 0.0651042 | 0.0410105 | 0.0410105 | 0.131234 | 0.104167 | 0.0375 | 0.09375 | 80 mmø-25 mmø | 0.082021 | 0.262467
666842 | Level 1 | 0.046875 | 10 | yes | no | 0.260417 | no | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1560 | Level: Level 2 | Level : Level 2 | 4708 | 0.260417 | 0.0410105 | 0.0651042 | 0.0410105 | 0.0410105 | 0.131234 | 0.104167 | 0.0375 | 0.09375 | 80 mmø-25 mmø | 0.082021 | 0.262467
667007 | Level 1 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1507.61 | Level: Level 2 | Level : Level 2 | 4726 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
667042 | Level 1 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1507.61 | Level: Level 2 | Level : Level 2 | 4727 | 0.135417 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.0656168 | 0.0541667 | 0.104167 | 0.260417 | 80 mmø-40 mmø | 0.262467 | 0.131234
667326 | Level 2 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 298.02 | Level: Level 2 | Level : Level 2 | 4764 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
667507 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1494.91 | Level: Level 2 | Level : Level 2 | 4789 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
677666 | TOF Footing | 0.109375 | 10 | yes | no | 0.34375 | no | 0.171875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 4885 | 0.34375 | 0.106627 | 0.0859375 | 0.106627 | 0.106627 | 0.164042 | 0.1375 | 0.0875 | 0.21875 | 100 mmø-65 mmø | 0.213255 | 0.328084
677791 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0572917 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 4917 | 0.114583 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0524934 | 0.0458333 | 0.1375 | 0.34375 | 100 mmø-32 mmø | 0.328084 | 0.104987
677965 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 4919 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
677966 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 4920 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
678339 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 4944 | 0.0729167 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0328084 | 0.0291667 | 0.0458333 | 0.114583 | 32 mmø-20 mmø | 0.104987 | 0.0656168
678341 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 4945 | 0.0729167 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0328084 | 0.0291667 | 0.0458333 | 0.114583 | 32 mmø-20 mmø | 0.104987 | 0.0656168
678403 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 4946 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
678405 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 4947 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
678461 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 4952 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
678529 | TOF Footing | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 4957 | 0.135417 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0656168 | 0.0541667 | 0.0875 | 0.21875 | 65 mmø-40 mmø | 0.213255 | 0.131234
678531 | TOF Footing | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 4958 | 0.09375 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0410105 | 0.0375 | 0.0541667 | 0.135417 | 40 mmø-25 mmø | 0.131234 | 0.082021
678558 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 4959 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
678559 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 4960 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
678796 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 4963 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
678797 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 4964 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
678833 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 4966 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
678905 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 4974 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
678906 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 4975 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
678991 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 4979 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
678992 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 4980 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
679026 | TOF Footing | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 4987 | 0.0520833 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0246063 | 0.0208333 | 0.0541667 | 0.135417 | 40 mmø-15 mmø | 0.131234 | 0.0492126
679161 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 4996 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
679188 | TOF Footing | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5003 | 0.0520833 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0246063 | 0.0208333 | 0.0875 | 0.21875 | 65 mmø-15 mmø | 0.213255 | 0.0492126
679353 | TOF Footing | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5021 | 0.0729167 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0328084 | 0.0291667 | 0.0875 | 0.21875 | 65 mmø-20 mmø | 0.213255 | 0.0656168
679395 | TOF Footing | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0885417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5030 | 0.177083 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.082021 | 0.0708333 | 0.0875 | 0.21875 | 65 mmø-50 mmø | 0.213255 | 0.164042
679413 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5036 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
679575 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 657.288 | Level: Level 1 | Level : Level 1 | 5056 | 0.09375 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0410105 | 0.0375 | 0.0541667 | 0.135417 | 40 mmø-25 mmø | 0.131234 | 0.082021
679593 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 371.263 | Level: Level 1 | Level : Level 1 | 5062 | 0.0520833 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0246063 | 0.0208333 | 0.0541667 | 0.135417 | 40 mmø-15 mmø | 0.131234 | 0.0492126
679765 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5068 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
679766 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5069 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
679817 | TOF Footing | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5075 | 0.0729167 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0328084 | 0.0291667 | 0.0541667 | 0.135417 | 40 mmø-20 mmø | 0.131234 | 0.0656168
679923 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5083 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
679924 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5084 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
680040 | TOF Footing | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5088 | 0.0520833 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0246063 | 0.0208333 | 0.0541667 | 0.135417 | 40 mmø-15 mmø | 0.131234 | 0.0492126
680152 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5106 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
680153 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5107 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
680186 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5111 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
680322 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 657.288 | Level: Level 1 | Level : Level 1 | 5129 | 0.09375 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0410105 | 0.0375 | 0.0541667 | 0.135417 | 40 mmø-25 mmø | 0.131234 | 0.082021
680339 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 371.263 | Level: Level 1 | Level : Level 1 | 5134 | 0.0520833 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0246063 | 0.0208333 | 0.0541667 | 0.135417 | 40 mmø-15 mmø | 0.131234 | 0.0492126
680372 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5140 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
680373 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5141 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
680464 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5145 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
680515 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5150 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
680516 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5151 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
680544 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5155 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
680665 | TOF Footing | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0885417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5174 | 0.177083 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.082021 | 0.0708333 | 0.0875 | 0.21875 | 65 mmø-50 mmø | 0.213255 | 0.164042
680979 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5182 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
680980 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5183 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
681054 | TOF Footing | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0885417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5187 | 0.177083 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.082021 | 0.0708333 | 0.0875 | 0.21875 | 65 mmø-50 mmø | 0.213255 | 0.164042
681233 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -500 | Level: Level 1 | Level : Level 1 | 5196 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
681235 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -500 | Level: Level 1 | Level : Level 1 | 5197 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
681271 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 654.113 | Level: Level 1 | Level : Level 1 | 5209 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
681292 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 371.263 | Level: Level 1 | Level : Level 1 | 5214 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
681371 | TOF Footing | 0.109375 | 10 | no | no | 0.21875 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5225 | 0.09375 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0410105 | 0.0375 | 0.0875 | 0.21875 | 65 mmø-25 mmø | 0.213255 | 0.082021
681508 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 654.831 | Level: Level 1 | Level : Level 1 | 5248 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
681611 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5263 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
681612 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5264 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
681673 | TOF Footing | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5268 | 0.0520833 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0246063 | 0.0208333 | 0.0875 | 0.21875 | 65 mmø-15 mmø | 0.213255 | 0.0492126
681792 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5283 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
681793 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5284 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
681815 | TOF Footing | 0.109375 | 10 | no | no | 0.21875 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5288 | 0.09375 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0410105 | 0.0375 | 0.0875 | 0.21875 | 65 mmø-25 mmø | 0.213255 | 0.082021
682006 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5307 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
682007 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5308 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
682148 | TOF Footing | 0.109375 | 10 | yes | no | 0.34375 | no | 0.171875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5317 | 0.34375 | 0.106627 | 0.0859375 | 0.106627 | 0.106627 | 0.164042 | 0.1375 | 0.0875 | 0.21875 | 100 mmø-65 mmø | 0.213255 | 0.328084
682183 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5327 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
682287 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 657.288 | Level: Level 1 | Level : Level 1 | 5342 | 0.09375 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0410105 | 0.0375 | 0.0541667 | 0.135417 | 40 mmø-25 mmø | 0.131234 | 0.082021
