Properties of the parts of a building model (IFC2X3), part 10 of 29

# IfcFlowFitting: Tee - Generic (541)
Name (M_Tee - Generic:Tee - Generic:Tee - Generic:...) | In | Center to End Label | Angle 1 (deg) | Fitting Outside Radius = Insulation Radius | Angle (deg) | Center to End | Fitting Outside Diameter | Size = Overall Size | Nominal Diameter | Tick Size | Nominal Radius | System Type | System Classification | Loss Method | System Name | Mark | Level | Offset (mm) | Host
664525 | Level 2 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4443 | Level: Level 2 | 500 | Level : Level 2
664911 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4474 | Level: Level 2 | -1688.2 | Level : Level 2
664959 | Level 2 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4480 | Level: Level 2 | 232.932 | Level : Level 2
665041 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4497 | Level: Level 2 | -1688.2 | Level : Level 2
665083 | Level 2 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4502 | Level: Level 2 | 232.932 | Level : Level 2
665228 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4524 | Level: Level 2 | -1688.2 | Level : Level 2
665263 | Level 2 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4528 | Level: Level 2 | 232.932 | Level : Level 2
665296 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4532 | Level: Level 2 | -1688.2 | Level : Level 2
665876 | Level 1 | 0.414943 | 45 | 0.171875 | 135 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4563 | Level: Level 2 | -1688.2 | Level : Level 2
665909 | Level 1 | 0.213758 | 45 | 0.0885417 | 45 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4568 | Level: Level 2 | -1688.2 | Level : Level 2
666118 | Level 2 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4589 | Level: Level 2 | 200 | Level : Level 2
666196 | TOF Footing | 0.41494 | 45.0003 | 0.171875 | 45.0003 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4604 | Level: Level 1 | -501.123 | Level : Level 1
666373 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4627 | Level: Level 1 | -500 | Level : Level 1
666517 | Level 1 | 0.414943 | 45 | 0.171875 | 135 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4640 | Level: Level 2 | -1560 | Level : Level 2
666624 | Level 2 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4661 | Level: Level 2 | 200 | Level : Level 2
666805 | Level 1 | 0.414943 | 45 | 0.171875 | 135 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4694 | Level: Level 2 | -1560 | Level : Level 2
666844 | Level 1 | 0.319312 | 44.3691 | 0.130208 | 44.3691 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4710 | Level: Level 2 | -1560 | Level : Level 2
666923 | Level 1 | 0.171875 | 90 | 0.130208 | 90 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4715 | Level: Level 2 | -1560 | Level : Level 2
667003 | Level 1 | 0.171875 | 90 | 0.130208 | 90 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4723 | Level: Level 2 | -1560 | Level : Level 2
667077 | Level 1 | 0.414943 | 45 | 0.171875 | 135 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4738 | Level: Level 2 | -1560 | Level : Level 2
667503 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4786 | Level: Level 2 | -1560 | Level : Level 2
669562 | Level 1 | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4795 | Level: Level 2 | -1688.2 | Level : Level 2
677787 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 4914 | Level: Level 1 | -512.678 | Level : Level 1
678460 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 4951 | Level: Level 1 | -512.678 | Level : Level 1
678524 | TOF Footing | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 4954 | Level: Level 1 | -512.678 | Level : Level 1
678730 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 4962 | Level: Level 1 | -512.678 | Level : Level 1
678948 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 4976 | Level: Level 1 | -512.678 | Level : Level 1
679022 | TOF Footing | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 4984 | Level: Level 1 | -512.678 | Level : Level 1
679184 | TOF Footing | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5000 | Level: Level 1 | -512.678 | Level : Level 1
679349 | TOF Footing | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5018 | Level: Level 1 | -512.678 | Level : Level 1
679589 | Level 1 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5059 | Level: Level 1 | 371.263 | Level : Level 1
679813 | TOF Footing | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5072 | Level: Level 1 | -512.678 | Level : Level 1
680036 | TOF Footing | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5085 | Level: Level 1 | -512.678 | Level : Level 1
680182 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5108 | Level: Level 1 | -512.678 | Level : Level 1
680335 | Level 1 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5131 | Level: Level 1 | 371.263 | Level : Level 1
680460 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5142 | Level: Level 1 | -512.678 | Level : Level 1
680540 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5152 | Level: Level 1 | -512.678 | Level : Level 1
680661 | TOF Footing | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5171 | Level: Level 1 | -512.678 | Level : Level 1
681050 | TOF Footing | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5184 | Level: Level 1 | -512.678 | Level : Level 1
681231 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 5195 | Level: Level 1 | -500 | Level : Level 1
681288 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5211 | Level: Level 1 | 371.263 | Level : Level 1
681367 | TOF Footing | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5222 | Level: Level 1 | -512.678 | Level : Level 1
681522 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5254 | Level: Level 1 | -512.678 | Level : Level 1
681669 | TOF Footing | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5265 | Level: Level 1 | -512.678 | Level : Level 1
681811 | TOF Footing | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5285 | Level: Level 1 | -512.678 | Level : Level 1
682101 | TOF Footing | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5309 | Level: Level 1 | -512.678 | Level : Level 1
682301 | Level 1 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5345 | Level: Level 1 | 371.263 | Level : Level 1
682533 | TOF Footing | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5353 | Level: Level 1 | -512.678 | Level : Level 1
682677 | TOF Footing | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5373 | Level: Level 1 | -512.678 | Level : Level 1
682784 | Level 1 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5390 | Level: Level 1 | 371.263 | Level : Level 1
683397 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 5407 | Level: Level 1 | -500 | Level : Level 1
683528 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 5421 | Level: Level 1 | -500 | Level : Level 1
683550 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 5432 | Level: Level 1 | -500 | Level : Level 1
683561 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5436 | Level: Level 1 | -512.678 | Level : Level 1
683651 | Level 1 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5455 | Level: Level 1 | 371.263 | Level : Level 1
683826 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5465 | Level: Level 1 | -512.678 | Level : Level 1
683992 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5494 | Level: Level 1 | -512.678 | Level : Level 1
684426 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5544 | Level: Level 1 | -512.678 | Level : Level 1
684450 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5553 | Level: Level 1 | -512.678 | Level : Level 1
684612 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5571 | Level: Level 1 | -512.678 | Level : Level 1
684792 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5593 | Level: Level 1 | -512.678 | Level : Level 1
684839 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5603 | Level: Level 1 | -512.678 | Level : Level 1
684969 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5626 | Level: Level 1 | -512.678 | Level : Level 1
685173 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5656 | Level: Level 1 | -512.678 | Level : Level 1
685454 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5672 | Level: Level 1 | -512.678 | Level : Level 1
685633 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5693 | Level: Level 1 | -512.678 | Level : Level 1
685862 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5735 | Level: Level 1 | 688.244 | Level : Level 1
685956 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5745 | Level: Level 1 | -512.678 | Level : Level 1
686120 | Level 1 | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5771 | Level: Level 1 | 688.244 | Level : Level 1
686390 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5785 | Level: Level 1 | -512.678 | Level : Level 1
686497 | TOF Footing | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5799 | Level: Level 1 | -512.678 | Level : Level 1
686590 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5813 | Level: Level 1 | -512.678 | Level : Level 1
686720 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5828 | Level: Level 1 | -512.678 | Level : Level 1
686871 | TOF Footing | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5850 | Level: Level 1 | -512.678 | Level : Level 1
686952 | TOF Footing | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5861 | Level: Level 1 | -512.678 | Level : Level 1
687195 | TOF Footing | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5884 | Level: Level 1 | -512.678 | Level : Level 1
687647 | Level 1 | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5941 | Level: Level 1 | 600 | Level : Level 1
687695 | TOF Footing | 0.213542 | 89.9997 | 0.171875 | 90.0003 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 5950 | Level: Level 1 | -501.123 | Level : Level 1
687758 | TOF Footing | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5958 | Level: Level 1 | -512.678 | Level : Level 1
687800 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5963 | Level: Level 1 | -512.678 | Level : Level 1
687912 | TOF Footing | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5978 | Level: Level 1 | -512.678 | Level : Level 1
687994 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 5994 | Level: Level 1 | -512.678 | Level : Level 1
688128 | TOF Footing | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6008 | Level: Level 1 | -512.678 | Level : Level 1
688261 | TOF Footing | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6021 | Level: Level 1 | -512.678 | Level : Level 1
688352 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6037 | Level: Level 1 | -512.678 | Level : Level 1
688520 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6060 | Level: Level 1 | -512.678 | Level : Level 1
688652 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6071 | Level: Level 1 | -512.678 | Level : Level 1
688667 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6076 | Level: Level 1 | -512.678 | Level : Level 1
688853 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6101 | Level: Level 1 | -512.678 | Level : Level 1
689020 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6128 | Level: Level 1 | -512.678 | Level : Level 1
689188 | Level 1 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6154 | Level: Level 1 | 500 | Level : Level 1
689252 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6160 | Level: Level 1 | -512.678 | Level : Level 1
689379 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6171 | Level: Level 1 | -512.678 | Level : Level 1
689546 | TOF Footing | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6182 | Level: Level 1 | -512.678 | Level : Level 1
689845 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6205 | Level: Level 1 | -512.678 | Level : Level 1
690022 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6237 | Level: Level 1 | -512.678 | Level : Level 1
690165 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6256 | Level: Level 1 | -512.678 | Level : Level 1
690271 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6273 | Level: Level 1 | -512.678 | Level : Level 1
690430 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6283 | Level: Level 1 | -512.678 | Level : Level 1
690503 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6292 | Level: Level 1 | -512.678 | Level : Level 1
690659 | TOF Footing | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6315 | Level: Level 1 | -512.678 | Level : Level 1
690850 | TOF Footing | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6325 | Level: Level 1 | -512.678 | Level : Level 1
690941 | TOF Footing | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6338 | Level: Level 1 | -512.678 | Level : Level 1
691091 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6376 | Level: Level 1 | -512.678 | Level : Level 1
691187 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6394 | Level: Level 1 | -512.678 | Level : Level 1
691274 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6411 | Level: Level 1 | -512.678 | Level : Level 1
691331 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6419 | Level: Level 1 | -512.678 | Level : Level 1
691510 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6441 | Level: Level 1 | -512.678 | Level : Level 1
691915 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6448 | Level: Level 1 | 3070 | Level : Level 1
691937 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6450 | Level: Level 2 | -1500 | Level : Level 2
692189 | Level 2 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6475 | Level: Level 2 | 200 | Level : Level 2
692210 | Level 2 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6485 | Level: Level 2 | 200 | Level : Level 2
692434 | Level 2 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6515 | Level: Level 2 | 200 | Level : Level 2
692580 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6519 | Level: Level 2 | -1500 | Level : Level 2
692787 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6550 | Level: Level 2 | -1500 | Level : Level 2
692979 | Level 2 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6580 | Level: Level 2 | 200 | Level : Level 2
693006 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6585 | Level: Level 2 | -1500 | Level : Level 2
693080 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6596 | Level: Level 1 | -512.678 | Level : Level 1
693448 | Level 2 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6617 | Level: Level 2 | 300 | Level : Level 2
694291 | Level 1 | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6694 | Level: Level 2 | -1500 | Level : Level 2
694574 | Level 1 | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6709 | Level: Level 2 | -1500 | Level : Level 2
694818 | Level 1 | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6736 | Level: Level 2 | -1500 | Level : Level 2
694994 | Level 1 | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6752 | Level: Level 2 | -1500 | Level : Level 2
695097 | Level 1 | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6771 | Level: Level 2 | -1500 | Level : Level 2
695250 | Level 1 | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6789 | Level: Level 2 | -1500 | Level : Level 2
695374 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6811 | Level: Level 2 | -1500 | Level : Level 2
695620 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6840 | Level: Level 2 | -1500 | Level : Level 2
696036 | Level 2 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6859 | Level: Level 2 | 200 | Level : Level 2
696082 | Level 2 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6870 | Level: Level 2 | 200 | Level : Level 2
696322 | Level 2 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6905 | Level: Level 2 | 200 | Level : Level 2
696363 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6912 | Level: Level 2 | -1500 | Level : Level 2
696412 | Level 1 | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6924 | Level: Level 2 | -1500 | Level : Level 2
696622 | Level 1 | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6936 | Level: Level 2 | -1500 | Level : Level 2
696763 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6951 | Level: Level 2 | -1500 | Level : Level 2
696866 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6968 | Level: Level 2 | -1500 | Level : Level 2
697025 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 6990 | Level: Level 2 | -1500 | Level : Level 2
697353 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 7031 | Level: Level 2 | -1500 | Level : Level 2
697660 | Level 1 | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 7074 | Level: Level 2 | -1500 | Level : Level 2
697677 | Level 1 | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 7075 | Level: Level 2 | -1500 | Level : Level 2
697702 | Level 1 | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 7080 | Level: Level 2 | -1500 | Level : Level 2
697761 | Level 1 | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 7094 | Level: Level 2 | -1500 | Level : Level 2
697993 | Level 1 | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 7112 | Level: Level 2 | -1500 | Level : Level 2
698135 | Level 1 | 0.171875 | 90 | 0.130208 | 90 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 7119 | Level: Level 2 | -1500 | Level : Level 2
698400 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 7149 | Level: Level 2 | -1560 | Level : Level 2
698525 | Level 1 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 7182 | Level: Level 2 | -1500 | Level : Level 2
698700 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 7193 | Level: Level 2 | -1560 | Level : Level 2
698836 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 7217 | Level: Level 2 | -1500 | Level : Level 2
698922 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 7237 | Level: Level 2 | -1500 | Level : Level 2
698939 | Level 2 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 7243 | Level: Level 2 | 200 | Level : Level 2
699002 | Level 1 | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 7267 | Level: Level 2 | -1500 | Level : Level 2
699129 | Level 1 | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 7279 | Level: Level 2 | -1500 | Level : Level 2
699419 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 7293 | Level: Level 2 | -1688.2 | Level : Level 2
699440 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 7303 | Level: Level 2 | -1688.2 | Level : Level 2
699458 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 7307 | Level: Level 2 | -1500 | Level : Level 2
699517 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 7325 | Level: Level 2 | -1500 | Level : Level 2
699604 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 7336 | Level: Level 2 | -1500 | Level : Level 2
700131 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7379 | Level: Level 1 | -300 | Level : Level 1
700408 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7403 | Level: Level 1 | -350 | Level : Level 1
700592 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7419 | Level: Level 1 | -300 | Level : Level 1
700754 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7435 | Level: Level 1 | -300 | Level : Level 1
700901 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7456 | Level: Level 1 | 300 | Level : Level 1
700935 | TOF Footing | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 7458 | Level: Level 1 | -512.678 | Level : Level 1
701082 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 7468 | Level: Level 1 | 200 | Level : Level 1
701100 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 7471 | Level: Level 1 | 200 | Level : Level 1
701114 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 7475 | Level: Level 1 | 200 | Level : Level 1
701352 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7503 | Level: Level 1 | -300 | Level : Level 1
701420 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7507 | Level: Level 1 | -300 | Level : Level 1
701564 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7526 | Level: Level 1 | -300 | Level : Level 1
701718 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7539 | Level: Level 1 | -300 | Level : Level 1
701853 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7553 | Level: Level 1 | -300 | Level : Level 1
701905 | TOF Footing | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 7564 | Level: Level 1 | -512.678 | Level : Level 1
702146 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7578 | Level: Level 1 | -300 | Level : Level 1
702217 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7590 | Level: Level 1 | -300 | Level : Level 1
702612 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 7654 | Level: Level 1 | -512.678 | Level : Level 1
702627 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7656 | Level: Level 1 | -300 | Level : Level 1
702654 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7666 | Level: Level 1 | -300 | Level : Level 1
702819 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7694 | Level: Level 1 | -300 | Level : Level 1
702904 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7700 | Level: Level 1 | -300 | Level : Level 1
703291 | TOF Footing | 0.0677083 | 90 | 0.0260417 | 90 | 0.0677083 | 0.0520833 | 15 mmø-15 mmø-15 mmø | 0.0492126 | 0.0208333 | 0.0246063 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7743 | Level: Level 1 | -300 | Level : Level 1
703589 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 7785 | Level: Level 1 | -500 | Level : Level 1
703631 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7795 | Level: Level 1 | -300 | Level : Level 1
703712 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7803 | Level: Level 1 | -300 | Level : Level 1
703889 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7823 | Level: Level 1 | -300 | Level : Level 1
704002 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7838 | Level: Level 1 | -300 | Level : Level 1
704143 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7853 | Level: Level 1 | -300 | Level : Level 1
704528 | TOF Footing | 0.0677083 | 90 | 0.0260417 | 90 | 0.0677083 | 0.0520833 | 15 mmø-15 mmø-15 mmø | 0.0492126 | 0.0208333 | 0.0246063 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7899 | Level: Level 1 | -300 | Level : Level 1
704910 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7913 | Level: Level 1 | -300 | Level : Level 1
705097 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7950 | Level: Level 1 | -250 | Level : Level 1
705165 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7961 | Level: Level 1 | -250 | Level : Level 1
705290 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 7980 | Level: Level 1 | -512.678 | Level : Level 1
705314 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7986 | Level: Level 1 | -250 | Level : Level 1
705375 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7994 | Level: Level 1 | -250 | Level : Level 1
705412 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 7998 | Level: Level 1 | -250 | Level : Level 1
705547 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8014 | Level: Level 1 | -300 | Level : Level 1
705757 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8033 | Level: Level 1 | -300 | Level : Level 1
706165 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8072 | Level: Level 1 | -300 | Level : Level 1
706301 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8085 | Level: Level 1 | -300 | Level : Level 1
706537 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8102 | Level: Level 1 | -300 | Level : Level 1
706614 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8111 | Level: Level 1 | -300 | Level : Level 1
707126 | TOF Footing | 0.0677083 | 90 | 0.0260417 | 90 | 0.0677083 | 0.0520833 | 15 mmø-15 mmø-15 mmø | 0.0492126 | 0.0208333 | 0.0246063 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8167 | Level: Level 1 | -300 | Level : Level 1
707239 | TOF Footing | 0.0677083 | 90 | 0.0260417 | 90 | 0.0677083 | 0.0520833 | 15 mmø-15 mmø-15 mmø | 0.0492126 | 0.0208333 | 0.0246063 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8196 | Level: Level 1 | -300 | Level : Level 1
707432 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 8236 | Level: Level 1 | -512.678 | Level : Level 1
707588 | TOF Footing | 0.0677083 | 90 | 0.0260417 | 90 | 0.0677083 | 0.0520833 | 15 mmø-15 mmø-15 mmø | 0.0492126 | 0.0208333 | 0.0246063 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8259 | Level: Level 1 | -300 | Level : Level 1
707743 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8264 | Level: Level 1 | -300 | Level : Level 1
707850 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8283 | Level: Level 1 | -300 | Level : Level 1
708025 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8317 | Level: Level 1 | -300 | Level : Level 1
708101 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8332 | Level: Level 1 | -300 | Level : Level 1
708232 | Level 1 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 8351 | Level: Level 1 | 688.244 | Level : Level 1
708406 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8372 | Level: Level 1 | -300 | Level : Level 1
708535 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8391 | Level: Level 1 | -300 | Level : Level 1
708797 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8435 | Level: Level 1 | -300 | Level : Level 1
708891 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8441 | Level: Level 1 | -300 | Level : Level 1
709018 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8455 | Level: Level 1 | -300 | Level : Level 1
709096 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8474 | Level: Level 1 | -300 | Level : Level 1
709298 | TOF Footing | 0.0677083 | 90 | 0.0260417 | 90 | 0.0677083 | 0.0520833 | 15 mmø-15 mmø-15 mmø | 0.0492126 | 0.0208333 | 0.0246063 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8493 | Level: Level 1 | -300 | Level : Level 1
709591 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8515 | Level: Level 1 | -300 | Level : Level 1
709614 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8523 | Level: Level 1 | -300 | Level : Level 1
709715 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8535 | Level: Level 1 | -250 | Level : Level 1
709843 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8562 | Level: Level 1 | -300 | Level : Level 1
710093 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8576 | Level: Level 1 | -300 | Level : Level 1
710240 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8589 | Level: Level 1 | -300 | Level : Level 1
710383 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8607 | Level: Level 1 | -300 | Level : Level 1
710519 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8628 | Level: Level 1 | -300 | Level : Level 1
710649 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8642 | Level: Level 1 | -300 | Level : Level 1
