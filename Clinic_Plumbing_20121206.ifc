Properties of the parts of a building model (IFC2X3), part 7 of 29

# IfcFlowFitting: Elbow - Generic (1654)
Name (M_Elbow - Generic:Elbow - Generic:Elbow - Generic:...) | In | Offset (mm) | Level | Host | Fitting Outside Radius = Insulation Radius | Center Radius | Overall Size = Size | System Classification | Loss Method | System Type | System Name | Angle (deg) | Nominal Radius | Center to End | Fitting Outside Diameter | Tick Size | Nominal Diameter | Mark
1074778 | Level 1 | -600 | Level: Level 2 | Level : Level 2 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Sanitary | 1 | Piping System: Storm | Storm | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13839
1074780 | Level 1 | -4270 | Level: Level 2 | Level : Level 2 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Sanitary | 1 | Piping System: Storm | Storm | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13841
1076202 | Level 1 | 0 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 13852
1076383 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 13878
1076679 | Level 1 | 500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 13886
1076681 | Level 1 | 500 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 13888
1076758 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 13892
1076859 | Level 1 | 771.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 29.3728 | 0.0246063 | 0.0122855 | 0.0520833 | 0.00546024 | 0.0492126 | 13902
1077098 | Level 1 | 400 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 13903
1077127 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 13908
1077150 | Level 1 | 635.088 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 13913
1077151 | Level 1 | 635.088 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.0781251 | 0.114583 | 0.0458334 | 0.104987 | 13914
1077172 | Level 1 | 635.088 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 13919
1077173 | Level 1 | 635.088 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 13920
1077238 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 5.16646 | 0.0328084 | 0.0025848 | 0.0729167 | 0.0013159 | 0.0656168 | 13929
1077294 | Level 1 | 725.231 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 13933
1077349 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 13940
1077364 | Level 1 | 728.763 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 13946
1077506 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 13948
1077529 | Level 1 | 635.088 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 13954
1077531 | Level 1 | 635.088 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 13956
1077595 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 19.061 | 0.0246063 | 0.00786985 | 0.0520833 | 0.00349771 | 0.0492126 | 13971
1077615 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 13978
1077639 | Level 1 | 0 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 13979
1077845 | Level 1 | 550 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 13983
1077945 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 13989
1077964 | Level 1 | 766.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 13995
1078047 | Level 1 | 635.088 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 14000
1078048 | Level 1 | 635.088 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14001
1078062 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14006
1078063 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14007
1078078 | Level 1 | 746.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14013
1078212 | Level 1 | 500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14018
1078312 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14026
1078438 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14034
1078497 | Level 1 | 766.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14042
1078516 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14048
1078743 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14050
1078825 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14058
1078840 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14064
1079113 | Level 1 | 543.338 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14073
1079156 | Level 1 | 748.763 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14083
1079189 | Level 1 | 806.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14088
1079190 | Level 1 | 806.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14089
1079205 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14095
1079494 | Level 1 | 100 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 55 | 0.0524934 | 0.0406693 | 0.114583 | 0.0238593 | 0.104987 | 14108
1079495 | Level 1 | 100 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14109
1079705 | Level 1 | 400 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14111
1079768 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14118
1079791 | Level 1 | 768.584 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14124
1079810 | Level 1 | 711.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14130
1079829 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14136
1079970 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 87.1092 | 0.0246063 | 0.0445677 | 0.0520833 | 0.0198079 | 0.0492126 | 14144
1079986 | Level 1 | 758.763 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 89.8505 | 0.0246063 | 0.0467529 | 0.0520833 | 0.020779 | 0.0492126 | 14150
1080034 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14154
1080052 | Level 1 | 635.088 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 14159
1080053 | Level 1 | 635.088 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14160
1080185 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 14164
1080340 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 14177
1080378 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14187
1080397 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14193
1080447 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14195
1080599 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14203
1080618 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14209
1080839 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 14218
1080841 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 82.0718 | 0.0656168 | 0.0770655 | 0.135417 | 0.047146 | 0.131234 | 14220
1080858 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 14222
1080890 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14232
1081076 | TOF Footing | -350 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14250
1081188 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 14254
1081189 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14255
1081208 | TOF Footing | -350 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14261
1081272 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14269
1081475 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14271
1081533 | Level 2 | 300 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14287
1081976 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14300
1082023 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14308
1082051 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14315
1082129 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14316
1082180 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 81.0969 | 0.0328084 | 0.0490155 | 0.0729167 | 0.0249534 | 0.0656168 | 14328
1082195 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14334
1082231 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14336
1082311 | Level 2 | 100 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14342
1082326 | Level 2 | 100 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14348
1082561 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14366
1082678 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14368
1082720 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14376
1082736 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14383
1082819 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14384
1082862 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14393
1082880 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14398
1082911 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14400
1083027 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 29.6095 | 0.0246063 | 0.012389 | 0.0520833 | 0.00550624 | 0.0492126 | 14410
1083044 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 50.1457 | 0.0246063 | 0.0219308 | 0.0520833 | 0.009747 | 0.0492126 | 14417
1083082 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14418
1083185 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14434
1083236 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14436
1083345 | Level 2 | 500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14444
1083364 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14450
1083515 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14457
1083535 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14463
1083675 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 14486
1083678 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 14488
1083686 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 14490
1083989 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 14514
1083990 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 14515
1084017 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14521
1084054 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 71.902 | 0.0246063 | 0.0339955 | 0.0520833 | 0.0151091 | 0.0492126 | 14529
1084312 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14536
1084411 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14553
1084508 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14565
1084528 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14572
1084768 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14577
1084846 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14585
1084865 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14591
1084935 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14593
1085029 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 80.9439 | 0.0246063 | 0.0399954 | 0.0520833 | 0.0177757 | 0.0492126 | 14605
1085044 | Level 1 | -500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14611
1085206 | Level 1 | -500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14625
1085225 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14631
1085697 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 14638
1085891 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14660
1085911 | Level 2 | 500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14668
1086087 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14677
1086109 | Level 2 | 500 | Level: Level 2 | Level : Level 2 | 0.0208333 | 0.0416667 | 10 mmø-10 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0164042 | 0.0416667 | 0.0416667 | 0.0166667 | 0.0328084 | 14681
1086468 | Level 1 | 908.719 | Level: Level 1 | Level : Level 1 | 0.0208333 | 0.0416667 | 10 mmø-10 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0164042 | 0.0416667 | 0.0416667 | 0.0166667 | 0.0328084 | 14695
1086469 | Level 1 | 908.719 | Level: Level 1 | Level : Level 1 | 0.0208333 | 0.0416667 | 10 mmø-10 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0164042 | 0.0416667 | 0.0416667 | 0.0166667 | 0.0328084 | 14696
1086485 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14701
1086664 | Level 1 | 873 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14725
1086677 | Level 1 | 873 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14729
1086786 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 14740
1086788 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 56 | 0.0656168 | 0.0470784 | 0.135417 | 0.0288009 | 0.131234 | 14742
1096326 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0208333 | 0.0416667 | 10 mmø-10 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.015625 | 0.0416667 | 0.0416667 | 0.0166667 | 0.03125 | 14847
1096339 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 14852
1096357 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 14862
1096779 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14873
1097990 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 14879
1097993 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 88.8376 | 0.131234 | 0.148008 | 0.260417 | 0.102074 | 0.262467 | 14881
1098063 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 14889
1098067 | Level 1 | 355.525 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14893
1098068 | Level 1 | 355.525 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14894
1098083 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14896
1098087 | Level 1 | 355.525 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14899
1098216 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 25.2621 | 0.131234 | 0.0338477 | 0.260417 | 0.0233433 | 0.262467 | 14904
1098217 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 14905
1098240 | Level 1 | 355.525 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14911
1098241 | Level 1 | 355.525 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14912
1098276 | Level 1 | 355.525 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14917
1098277 | Level 1 | 355.525 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14918
1098421 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 14934
1098423 | TOF Footing | -501.083 | Level: Level 1 | Level : Level 1 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 89.9977 | 0.131234 | 0.151036 | 0.260417 | 0.104163 | 0.262467 | 14936
1098425 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 32.5227 | 0.131234 | 0.044057 | 0.260417 | 0.0303842 | 0.262467 | 14938
1098441 | TOF Footing | -501.1 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 14941
1098497 | Level 1 | 355.525 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14945
1098501 | Level 1 | 355.525 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14948
1098511 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14949
1098515 | Level 1 | 355.525 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14952
1098601 | Level 1 | -411 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 37.669 | 0.0524934 | 0.0266484 | 0.114583 | 0.0156337 | 0.104987 | 14959
1098602 | Level 1 | -411 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 14960
1098756 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14963
1098759 | Level 2 | 355.525 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14966
1098760 | Level 2 | 355.525 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14967
1098771 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14969
1098775 | Level 2 | 355.525 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14972
1099020 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 89.001 | 0.131234 | 0.148431 | 0.260417 | 0.102366 | 0.262467 | 14982
1099022 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 14983
1099055 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14985
1099059 | Level 2 | 355.525 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14988
1099074 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14990
1099078 | Level 2 | 355.525 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 14993
1099210 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 89.5646 | 0.131234 | 0.149898 | 0.260417 | 0.103378 | 0.262467 | 14998
1099211 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 14999
1099325 | Level 1 | 355.525 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15004
1099326 | Level 1 | 355.525 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15005
1099371 | Level 1 | 355.525 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15010
1099372 | Level 1 | 355.525 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15011
1109895 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 15021
1110132 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 15027
1110134 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 38.9428 | 0.164042 | 0.0681334 | 0.34375 | 0.0486141 | 0.328084 | 15029
1117850 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 15107
1117852 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 67 | 0.082021 | 0.0723937 | 0.177083 | 0.0468836 | 0.164042 | 15109
1117948 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15113
1122929 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15195
1122930 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15196
1122940 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15200
1123086 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 15209
1123087 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 15210
1123093 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 15214
1123094 | Level 1 | -1430 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 15215
1123644 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15228
1123650 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15232
1123652 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15234
1123654 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15236
1124092 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15244
1124098 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15248
1124100 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15250
1124102 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15252
1124115 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15254
1124121 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15258
1124123 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15260
1124125 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15262
1124226 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15264
1124228 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15266
1124259 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15269
1124261 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15271
1124263 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15273
1124356 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 45 | 0.0410105 | 0.0280457 | 0.09375 | 0.015533 | 0.082021 | 15284
1124359 | Level 1 | -1430 | Level: Level 2 | Level : Level 2 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 45 | 0.0410105 | 0.0280457 | 0.09375 | 0.015533 | 0.082021 | 15286
1124368 | Level 1 | -1430 | Level: Level 2 | Level : Level 2 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 15289
1124394 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15291
1124437 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15295
1124455 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15299
1124710 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 15310
1124711 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 15311
1124811 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15323
1124812 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15324
1124923 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15327
1124929 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15331
1124931 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15333
1124933 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15335
1124943 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 15338
1124950 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 15342
1124952 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 15344
1124954 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 15346
1125095 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15350
1125101 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15354
1125103 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15356
1125105 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15358
1125131 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 15360
1125137 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 15364
1125139 | Level 1 | -1480 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 15366
1125141 | Level 1 | -1480 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 15368
1125273 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15373
1125279 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15377
1125281 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15379
1125283 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15381
1125833 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 45 | 0.0656168 | 0.0366752 | 0.135417 | 0.0224366 | 0.131234 | 15396
1125839 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 45 | 0.0656168 | 0.0366752 | 0.135417 | 0.0224366 | 0.131234 | 15400
