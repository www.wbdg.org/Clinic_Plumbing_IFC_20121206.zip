Properties of the parts of a building model (IFC2X3), part 6 of 29

# IfcFlowFitting: Elbow - Generic (1654)
Name (M_Elbow - Generic:Elbow - Generic:Elbow - Generic:...) | In | Offset (mm) | Level | Host | Fitting Outside Radius = Insulation Radius | Center Radius | Overall Size = Size | System Classification | Loss Method | System Type | System Name | Angle (deg) | Nominal Radius | Center to End | Fitting Outside Diameter | Tick Size | Nominal Diameter | Mark
708231 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 8350
708276 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 61.8311 | 0.0246063 | 0.0280714 | 0.0520833 | 0.0124762 | 0.0492126 | 8362
708354 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8366
708359 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8370
708417 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8377
708471 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8382
708472 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8383
708489 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8388
708544 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8395
708551 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8396
708595 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8401
708596 | Level 1 | 500 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8402
708614 | Level 1 | 500 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8409
708669 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8422
708692 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8423
708693 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8424
708796 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8434
708900 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8445
708938 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8446
708939 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8447
708952 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8452
709037 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8463
709075 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8466
709076 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8467
709089 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8473
709142 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8477
709143 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8478
709276 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8488
709277 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8489
709279 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8491
709346 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8495
709526 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8509
709612 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8521
709638 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8525
709677 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8526
709678 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8527
709852 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8566
709990 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8567
709991 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8568
710134 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8580
710253 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8593
710307 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8598
710308 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8599
710319 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8604
710392 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8611
710449 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8619
710450 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8620
710461 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8625
710532 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8632
710541 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8634
710606 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8635
710685 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8645
710686 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8646
710699 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8651
710873 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8660
710874 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8661
711025 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8688
711084 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8694
711092 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8700
711163 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8710
711171 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8716
711232 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8723
711233 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8724
711246 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8729
711333 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8750
711334 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8751
711612 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8764
711613 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8765
711626 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8770
712189 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8831
712191 | Level 2 | 300 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8833
712202 | Level 2 | 300 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8838
712216 | Level 2 | 300 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8840
712226 | Level 2 | 300 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8844
712358 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8851
712609 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8852
712615 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8857
712767 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8875
712805 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8876
712806 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8877
712998 | Level 1 | 3140 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 8891
713000 | Level 1 | -1430 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8893
713073 | Level 1 | -1430 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8903
713074 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8904
713250 | Level 1 | -1430 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8916
713252 | Level 2 | 300 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8918
713287 | Level 2 | 300 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8925
713333 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8932
713340 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8933
713402 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8940
713403 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8941
713549 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 8950
713562 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 8953
713639 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8964
713684 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8973
713781 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8979
713830 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 8992
713867 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 8995
713868 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 8996
713881 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 9001
713917 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 45 | 0.0328084 | 0.023731 | 0.0729167 | 0.0120812 | 0.0656168 | 9008
713922 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 9012
713923 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 45 | 0.0328084 | 0.023731 | 0.0729167 | 0.0120812 | 0.0656168 | 9013
714001 | Level 1 | 3170 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 9024
714559 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 9061
714650 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9069
714651 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9070
714662 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9075
714931 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9092
714932 | Level 2 | 300 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9093
715173 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 9108
715188 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 9109
715189 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 9110
715231 | Level 1 | 3170 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 9111
715256 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 9114
715279 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9121
715333 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9128
715334 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9129
715347 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9134
715620 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9152
715716 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 9165
715792 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 9178
715832 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9186
716018 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 9205
716334 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9228
716335 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9229
716387 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 9239
716637 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 9262
716841 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9275
716842 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9276
717036 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9299
717037 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9300
717145 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9314
717185 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9315
717186 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9316
717263 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9328
717305 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9329
717306 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9330
717390 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9342
717446 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9345
717447 | Level 2 | 100 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9346
717597 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9359
717641 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9364
717642 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9365
717732 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9373
717779 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9380
717780 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9381
717877 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 9394
717898 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 9398
718418 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 9399
718427 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 9405
718446 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 9412
718557 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9423
718586 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9424
718587 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9425
718695 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9437
718753 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9441
718754 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9442
718886 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9457
718929 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9460
718930 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9461
719013 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9476
719197 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9483
719241 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9488
719242 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9489
719359 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9498
719365 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9503
719411 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9517
719714 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9537
719715 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9538
719726 | Level 2 | 200.001 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9543
724172 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 9758
997584 | Level 2 | 100 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 9983
997585 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.046875 | 0.0677083 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.0677083 | 0.09375 | 0.0375 | 0.0492126 | 9984
997587 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.046875 | 0.0677083 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.0677083 | 0.09375 | 0.0375 | 0.0492126 | 9986
997988 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.046875 | 0.0677083 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90.039 | 0.082021 | 0.0677083 | 0.09375 | 0.0375 | 0.164042 | 10008
998841 | Level 1 | 3000 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0677083 | 0.09375 | 0.0375 | 0.131234 | 10024
998845 | Level 1 | 3000 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 36.3694 | 0.0656168 | 0.0677083 | 0.09375 | 0.0375 | 0.131234 | 10027
1001032 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 10113
1001048 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 10119
1001049 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.0656168 | 0.0366752 | 0.135417 | 0.0224366 | 0.131234 | 10120
1054475 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 13399
1054518 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.109375 | 0.130208 | 65 mmø-65 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.106627 | 0.130208 | 0.21875 | 0.0875 | 0.213255 | 13407
1054525 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.109375 | 0.130208 | 65 mmø-65 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.106627 | 0.130208 | 0.21875 | 0.0875 | 0.213255 | 13409
1056717 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 13432
1056719 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 13434
1061427 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.109375 | 0.130208 | 65 mmø-65 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.106627 | 0.130208 | 0.21875 | 0.0875 | 0.213255 | 13437
1061446 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.109375 | 0.130208 | 65 mmø-65 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.106627 | 0.130208 | 0.21875 | 0.0875 | 0.213255 | 13439
1061797 | Level 2 | 381 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 13468
1061798 | Level 2 | 381 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 13469
1067036 | TOF Footing | -600 | Level: Level 1 | Level : Level 1 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Return | 1 | Piping System: Hydronic Return 1 | Hydronic Return 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13530
1067041 | TOF Footing | -600 | Level: Level 1 | Level : Level 1 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Return | 1 | Piping System: Hydronic Return 1 | Hydronic Return 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13531
1067052 | TOF Footing | -600 | Level: Level 1 | Level : Level 1 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Return | 1 | Piping System: Hydronic Return 1 | Hydronic Return 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13533
1067500 | TOF Footing | -600 | Level: Level 1 | Level : Level 1 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Return | 1 | Piping System: Hydronic Return 1 | Hydronic Return 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13547
1067501 | TOF Footing | -600 | Level: Level 1 | Level : Level 1 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Return | 1 | Piping System: Hydronic Return 1 | Hydronic Return 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13548
1067593 | TOF Footing | -600 | Level: Level 1 | Level : Level 1 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Supply | 1 | Piping System: Hydronic Supply 1 | Hydronic Supply 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13554
1067840 | TOF Footing | -600 | Level: Level 1 | Level : Level 1 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Return | 1 | Piping System: Hydronic Return 1 | Hydronic Return 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13559
1067883 | TOF Footing | -600 | Level: Level 1 | Level : Level 1 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Return | 1 | Piping System: Hydronic Return 1 | Hydronic Return 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13563
1067884 | TOF Footing | -5170 | Level: Level 2 | Level : Level 2 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Return | 1 | Piping System: Hydronic Return 1 | Hydronic Return 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13564
1067941 | Level 1 | -1670 | Level: Level 2 | Level : Level 2 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Return | 1 | Piping System: Hydronic Return 1 | Hydronic Return 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13566
1067947 | Level 1 | -1670 | Level: Level 2 | Level : Level 2 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Return | 1 | Piping System: Hydronic Return 1 | Hydronic Return 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13568
1067954 | Level 1 | -1670 | Level: Level 2 | Level : Level 2 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Return | 1 | Piping System: Hydronic Return 1 | Hydronic Return 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13569
1068027 | Level 1 | -1670 | Level: Level 2 | Level : Level 2 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Return | 1 | Piping System: Hydronic Return 1 | Hydronic Return 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13571
1068540 | Level 1 | 571 | Level: Level 1 | Level : Level 1 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Supply | 1 | Piping System: Hydronic Supply 1 | Hydronic Supply 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13617
1068589 | TOF Footing | -600 | Level: Level 1 | Level : Level 1 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Supply | 1 | Piping System: Hydronic Supply 1 | Hydronic Supply 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13619
1068600 | TOF Footing | -600 | Level: Level 1 | Level : Level 1 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Supply | 1 | Piping System: Hydronic Supply 1 | Hydronic Supply 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13620
1068607 | TOF Footing | -600 | Level: Level 1 | Level : Level 1 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Supply | 1 | Piping System: Hydronic Supply 1 | Hydronic Supply 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13621
1068622 | TOF Footing | -600 | Level: Level 1 | Level : Level 1 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Supply | 1 | Piping System: Hydronic Supply 1 | Hydronic Supply 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13624
1068627 | TOF Footing | -600 | Level: Level 1 | Level : Level 1 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Supply | 1 | Piping System: Hydronic Supply 1 | Hydronic Supply 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13625
1068653 | TOF Footing | -600 | Level: Level 1 | Level : Level 1 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Supply | 1 | Piping System: Hydronic Supply 1 | Hydronic Supply 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13635
1068690 | TOF Footing | -600 | Level: Level 1 | Level : Level 1 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Supply | 1 | Piping System: Hydronic Supply 1 | Hydronic Supply 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13637
1068692 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Supply | 1 | Piping System: Hydronic Supply 1 | Hydronic Supply 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13639
1068763 | Level 1 | -1670 | Level: Level 2 | Level : Level 2 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Supply | 1 | Piping System: Hydronic Supply 1 | Hydronic Supply 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13641
1068770 | Level 1 | -1670 | Level: Level 2 | Level : Level 2 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Supply | 1 | Piping System: Hydronic Supply 1 | Hydronic Supply 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13642
1068775 | Level 1 | -1670 | Level: Level 2 | Level : Level 2 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Supply | 1 | Piping System: Hydronic Supply 1 | Hydronic Supply 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13643
1068886 | Level 1 | -1670 | Level: Level 2 | Level : Level 2 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Supply | 1 | Piping System: Hydronic Supply 1 | Hydronic Supply 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13646
1068911 | Level 2 | 3800 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Hydronic Supply | 1 | Piping System: Hydronic Supply 1 | Hydronic Supply 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 13654
1070101 | Level 2 | 3800 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Hydronic Supply | 1 | Piping System: Hydronic Supply 1 | Hydronic Supply 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 13678
1070102 | Level 2 | 3800 | Level: Level 2 | Level : Level 2 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Supply | 1 | Piping System: Hydronic Supply 1 | Hydronic Supply 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13679
1070117 | Level 2 | 4000 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Hydronic Return | 1 | Piping System: Hydronic Return 1 | Hydronic Return 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 13681
1070118 | Level 2 | 4000 | Level: Level 2 | Level : Level 2 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Return | 1 | Piping System: Hydronic Return 1 | Hydronic Return 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13682
1070243 | Level 2 | 38.1 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Hydronic Return | 1 | Piping System: Hydronic Return 1 | Hydronic Return 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 13700
1070303 | Level 2 | 3800 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Hydronic Supply | 1 | Piping System: Hydronic Supply 1 | Hydronic Supply 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 13712
1070330 | Level 2 | 4000 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Hydronic Return | 1 | Piping System: Hydronic Return 1 | Hydronic Return 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 13722
1070444 | Level 2 | 3800 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Hydronic Supply | 1 | Piping System: Hydronic Supply 1 | Hydronic Supply 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 13730
1070461 | Level 2 | 38.1 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Hydronic Return | 1 | Piping System: Hydronic Return 1 | Hydronic Return 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 13733
1070464 | Level 2 | 4000 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Hydronic Return | 1 | Piping System: Hydronic Return 1 | Hydronic Return 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 13736
1070465 | Level 2 | 4000 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Hydronic Return | 1 | Piping System: Hydronic Return 1 | Hydronic Return 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 13737
1071561 | Level 1 | 287 | Level: Level 1 | Level : Level 1 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Return | 1 | Piping System: Hydronic Return 1 | Hydronic Return 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13744
1072568 | Level 1 | 571 | Level: Level 1 | Level : Level 1 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Hydronic Supply | 1 | Piping System: Hydronic Supply 1 | Hydronic Supply 1 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13747
1072607 | Level 2 | 38.1 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Hydronic Supply | 1 | Piping System: Hydronic Supply 1 | Hydronic Supply 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 13748
1072629 | Level 2 | 38.1 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Hydronic Supply | 1 | Piping System: Hydronic Supply 1 | Hydronic Supply 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 13750
1073577 | Level 2 | 300 | Level: Level 2 | Level : Level 2 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Sanitary | 1 | Piping System: Sanitary | Sanitary 3 | 90 | 0.246063 | 0.276042 | 0.510417 | 0.204167 | 0.492126 | 13767
1074690 | Level 1 | -600 | Level: Level 2 | Level : Level 2 | 0.255208 | 0.276042 | 150 mmø-150 mmø | Sanitary | 1 | Piping System: Storm | Storm | 45 | 0.246063 | 0.11434 | 0.510417 | 0.0845686 | 0.492126 | 13833
