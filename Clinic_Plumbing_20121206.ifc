Properties of the parts of a building model (IFC2X3), part 24 of 29

# IfcFlowSegment: Pipe Types:Hot Water:699832 (871)
Name (Pipe Types:Hot Water:...) | In | System Type | Invert Elevation (mm) | System Name | System Classification | Area (mm2) | Diameter | Section | Offset (mm) = Start Offset (mm) | Slope | End Offset (mm) | Reference Level | Reynolds Number | Flow State | Friction | Relative Roughness | Velocity | Friction Factor | Pressure Drop | Fixture Units | Flow | Inner Diameter | Size = Overall Size | Length (mm) | Outer Diameter | Mark
712752 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 29762.6 | 0.0492126 | 435 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 631.581 | 0.0416667 | 3220
712759 | Level 2 | Piping System: Domestic Hot Water 1 | 3158.72 | Domestic Hot Water 1 | Domestic Hot Water | 23693 | 0.082021 | 433 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 301.669 | 0.0833333 | 3221
712763 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 221695 | 0.0492126 | 437 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 4704.52 | 0.0416667 | 3222
712768 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 4981.58 | 0.0492126 | 437 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 105.713 | 0.0416667 | 3223
712804 | Level 2 | Piping System: Domestic Hot Water 1 | 3184.29 | Domestic Hot Water 1 | Domestic Hot Water | 74051.7 | 0.0492126 | 437 | -1385.71 |  | 185.713 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1571.43 | 0.0416667 | 3224
712899 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 2456.62 | 0.0492126 | 435 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 52.1312 | 0.0416667 | 3226
712956 | Level 2 | Piping System: Domestic Hot Water 1 | 3134.67 | Domestic Hot Water 1 | Domestic Hot Water | 43976.8 | 0.0492126 | 440 | -1430 | 0 | -1430 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 933.216 | 0.0416667 | 3227
712961 | Level 2 | Piping System: Domestic Hot Water 1 | 3128.72 | Domestic Hot Water 1 | Domestic Hot Water | 49579.2 | 0.082021 | 438 | -1430 | 0 | -1430 | Level: Level 2 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 631.262 | 0.0833333 | 3228
713030 | Level 2 | Piping System: Domestic Hot Water 1 | 3134.67 | Domestic Hot Water 1 | Domestic Hot Water | 124251 | 0.0492126 | 446 | -1430 | 0 | -1430 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 2636.69 | 0.0416667 | 3229
713040 | Level 2 | Piping System: Domestic Hot Water 1 | 3122.58 | Domestic Hot Water 1 | Domestic Hot Water | 223742 | 0.131234 | 442 | -1430 | 0 | -1430 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 1780.48 | 0.125 | 3230
713044 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 5924.06 | 0.0492126 | 446 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 125.713 | 0.0416667 | 3231
713072 | Level 2 | Piping System: Domestic Hot Water 1 | 3154.29 | Domestic Hot Water 1 | Domestic Hot Water | 75465.4 | 0.0492126 | 446 | -1415.71 |  | 185.713 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1601.43 | 0.0416667 | 3232
713158 | Level 2 | Piping System: Domestic Hot Water 1 | 3134.67 | Domestic Hot Water 1 | Domestic Hot Water | 19006.2 | 0.0492126 | 444 | -1430 | 0 | -1430 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 403.324 | 0.0416667 | 3234
713184 | Level 2 | Piping System: Domestic Hot Water 1 | 3134.67 | Domestic Hot Water 1 | Domestic Hot Water | 14333.8 | 0.0492126 | 451 | -1430 | 0 | -1430 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 304.172 | 0.0416667 | 3235
713189 | Level 2 | Piping System: Domestic Hot Water 1 | 3122.58 | Domestic Hot Water 1 | Domestic Hot Water | 115657 | 0.131234 | 447 | -1430 | 0 | -1430 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 920.366 | 0.125 | 3236
713193 | Level 2 | Piping System: Domestic Hot Water 1 | 4864.67 | Domestic Hot Water 1 | Domestic Hot Water | 101167 | 0.0492126 | 451 | 300 | 0 | 300 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 2146.83 | 0.0416667 | 3237
713249 | Level 2 | Piping System: Domestic Hot Water 1 | 3154.29 | Domestic Hot Water 1 | Domestic Hot Water | 80177.8 | 0.0492126 | 451 | -1415.71 |  | 285.712 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1701.43 | 0.0416667 | 3238
713281 | Level 2 | Piping System: Domestic Hot Water 1 | 4864.67 | Domestic Hot Water 1 | Domestic Hot Water | 13064.6 | 0.0492126 | 451 | 300 | 0 | 300 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 277.239 | 0.0416667 | 3240
713301 | Level 2 | Piping System: Domestic Hot Water 1 | 3134.67 | Domestic Hot Water 1 | Domestic Hot Water | 25112.2 | 0.0492126 | 449 | -1430 | 0 | -1430 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 532.896 | 0.0416667 | 3241
713318 | Level 2 | Piping System: Domestic Hot Water 1 | 3064.67 | Domestic Hot Water 1 | Domestic Hot Water | 18946.5 | 0.0492126 | 24 | -1500 | 0 | -1500 | Level: Level 2 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 1161.22 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 402.056 | 0.0416667 | 3242
713325 | Level 2 | Piping System: Domestic Hot Water 1 | 3052.58 | Domestic Hot Water 1 | Domestic Hot Water | 1499020 | 0.131234 | 452 | -1500 | 0 | -1500 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 11928.8 | 0.125 | 3243
713329 | Level 2 | Piping System: Domestic Hot Water 1 | 3064.67 | Domestic Hot Water 1 | Domestic Hot Water | 48392.2 | 0.0492126 | 22 | -1500 | 0 | -1500 | Level: Level 2 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 2965.93 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 1026.91 | 0.0416667 | 3244
713334 | Level 2 | Piping System: Domestic Hot Water 1 | 3064.67 | Domestic Hot Water 1 | Domestic Hot Water | 150392 | 0.0492126 | 22 | -1500 | 0 | -1500 | Level: Level 2 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 9217.46 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 3191.43 | 0.0416667 | 3245
713341 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 2735.16 | 0.0492126 | 22 | 200 | 0 | 200 | Level: Level 2 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 167.636 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 58.0418 | 0.0416667 | 3246
713401 | Level 2 | Piping System: Domestic Hot Water 1 | 3084.29 | Domestic Hot Water 1 | Domestic Hot Water | 78764 | 0.0492126 | 22 | -1485.71 |  | 185.713 | Level: Level 2 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 4827.4 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 1671.43 | 0.0416667 | 3247
713416 | Level 2 | Piping System: Domestic Hot Water 1 | 3064.67 | Domestic Hot Water 1 | Domestic Hot Water | 13815.1 | 0.0492126 | 24 | -1500 | 0 | -1500 | Level: Level 2 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 846.721 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 293.166 | 0.0416667 | 3248
713459 | Level 2 | Piping System: Domestic Hot Water 1 | 3064.67 | Domestic Hot Water 1 | Domestic Hot Water | 290400 | 0.0492126 | 646 | -1500 | 0 | -1500 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 6162.47 | 0.0416667 | 3249
713531 | Level 2 | Piping System: Domestic Hot Water 1 | 3046.23 | Domestic Hot Water 1 | Domestic Hot Water | 1532024 | 0.164042 | 653 | -1500 | 0 | -1500 | Level: Level 2 | 0 | 0 | 0 | 18716.5 | 0 | 0 | 0 | 0 | 0 | 0.155971 | 50 mmø | 9753.17 | 0.166667 | 3250
713545 | Level 2 | Piping System: Domestic Hot Water 1 | 3146.23 | Domestic Hot Water 1 | Domestic Hot Water | 72257.3 | 0.164042 | 641 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 18716.5 | 0 | 0 | 0 | 0 | 0 | 0.155971 | 50 mmø | 460.004 | 0.166667 | 3252
713550 | Level 2 | Piping System: Domestic Hot Water 1 | 3146.23 | Domestic Hot Water 1 | Domestic Hot Water | 388122 | 0.164042 | 641 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 18716.5 | 0 | 0 | 0 | 0 | 0 | 0.155971 | 50 mmø | 2470.86 | 0.166667 | 3253
713611 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 976217 | 0.0656168 | 455 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 15537 | 0.0625 | 3255
713635 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 33871.1 | 0.0656168 | 455 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 539.076 | 0.0625 | 3256
713640 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 186577 | 0.0656168 | 455 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 2969.46 | 0.0625 | 3257
713766 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 451319 | 0.0656168 | 644 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 7182.96 | 0.0625 | 3260
713775 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 58124.2 | 0.0656168 | 648 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 925.075 | 0.0625 | 3262
713782 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 2463.13 | 0.0656168 | 648 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 39.2019 | 0.0625 | 3263
713792 | Level 2 | Piping System: Domestic Hot Water 1 | 3152.58 | Domestic Hot Water 1 | Domestic Hot Water | 291332 | 0.131234 | 460 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 2318.35 | 0.125 | 3264
713797 | Level 2 | Piping System: Domestic Hot Water 1 | 3146.23 | Domestic Hot Water 1 | Domestic Hot Water | 2664708 | 0.164042 | 641 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 18716.5 | 0 | 0 | 0 | 0 | 0 | 0.155971 | 50 mmø | 16964.1 | 0.166667 | 3265
713801 | Level 2 | Piping System: Domestic Hot Water 1 | 3152.58 | Domestic Hot Water 1 | Domestic Hot Water | 31292.1 | 0.131234 | 673 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 249.015 | 0.125 | 3266
713831 | Level 2 | Piping System: Domestic Hot Water 1 | 4752.58 | Domestic Hot Water 1 | Domestic Hot Water | 3524.74 | 0.131234 | 673 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 28.049 | 0.125 | 3267
713866 | Level 2 | Piping System: Domestic Hot Water 1 | 3196.99 | Domestic Hot Water 1 | Domestic Hot Water | 194279 | 0.131234 | 673 | -1373.01 |  | 173.013 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 1546.03 | 0.125 | 3268
713870 | Level 2 | Piping System: Domestic Hot Water 1 | 4752.58 | Domestic Hot Water 1 | Domestic Hot Water | 4958.37 | 0.131234 | 673 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 39.4575 | 0.125 | 3269
713912 | Level 2 | Piping System: Domestic Hot Water 1 | 3152.58 | Domestic Hot Water 1 | Domestic Hot Water | 2711.41 | 0.131234 | 457 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 21.5767 | 0.125 | 3271
713913 | Level 2 | Piping System: Domestic Hot Water 1 | 3169.38 | Domestic Hot Water 1 | Domestic Hot Water | 3533.93 | 0.0656168 | 648 | -1394.89 | 1 | -1355.11 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 56.2443 | 0.0625 | 3272
713915 | Level 2 | Piping System: Domestic Hot Water 1 | 3152.58 | Domestic Hot Water 1 | Domestic Hot Water | 115043 | 0.131234 | 456 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 915.484 | 0.125 | 3273
713967 | Level 2 | Piping System: Domestic Hot Water 1 | 3152.58 | Domestic Hot Water 1 | Domestic Hot Water | 63040.9 | 0.131234 | 458 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 501.664 | 0.125 | 3274
713979 | Level 1 | Piping System: Domestic Hot Water 1 | -276.188 | Domestic Hot Water 1 | Domestic Hot Water | 344055 | 0.104987 | 270 | -276.188 |  | 3146.19 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 3422.38 | 0.104167 | 3276
714004 | Level 2 | Piping System: Domestic Hot Water 1 | 3152.58 | Domestic Hot Water 1 | Domestic Hot Water | 580078 | 0.131234 | 459 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 4616.11 | 0.125 | 3278
714032 | Level 2 | Piping System: Domestic Hot Water 1 | 3152.58 | Domestic Hot Water 1 | Domestic Hot Water | 55211.8 | 0.131234 | 460 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 439.362 | 0.125 | 3279
714090 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 60803.4 | 0.0656168 | 644 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 967.716 | 0.0625 | 3280
714246 | Level 2 | Piping System: Domestic Hot Water 1 | 3139.88 | Domestic Hot Water 1 | Domestic Hot Water | 29916.9 | 0.213255 | 5 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 23716.5 | 0 | 0 | 0 | 0 | 0 | 0.197638 | 65 mmø | 146.505 | 0.208333 | 3282
714298 | Level 2 | Piping System: Domestic Hot Water 1 | 3139.88 | Domestic Hot Water 1 | Domestic Hot Water | 72057.3 | 0.213255 | 463 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 23716.5 | 0 | 0 | 0 | 0 | 0 | 0.197638 | 65 mmø | 352.87 | 0.208333 | 3283
714440 | Level 2 | Piping System: Domestic Hot Water 1 | 3152.58 | Domestic Hot Water 1 | Domestic Hot Water | 663348 | 0.131234 | 481 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 5278.76 | 0.125 | 3287
714450 | Level 2 | Piping System: Domestic Hot Water 1 | 3139.88 | Domestic Hot Water 1 | Domestic Hot Water | 86397.9 | 0.213255 | 465 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 23716.5 | 0 | 0 | 0 | 0 | 0 | 0.197638 | 65 mmø | 423.097 | 0.208333 | 3288
714471 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 222325 | 0.0656168 | 471 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 3538.42 | 0.0625 | 3289
714476 | Level 2 | Piping System: Domestic Hot Water 1 | 3152.58 | Domestic Hot Water 1 | Domestic Hot Water | 92108.7 | 0.131234 | 467 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 732.978 | 0.125 | 3290
714480 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 30565.7 | 0.0656168 | 689 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 486.469 | 0.0625 | 3291
714560 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 12725.8 | 0.0656168 | 689 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 202.538 | 0.0625 | 3292
714565 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 49487.4 | 0.0492126 | 677 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1050.16 | 0.0416667 | 3293
714581 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 2549.9 | 0.0492126 | 677 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 54.1105 | 0.0416667 | 3294
714649 | Level 2 | Piping System: Domestic Hot Water 1 | 3184.29 | Domestic Hot Water 1 | Domestic Hot Water | 74051.7 | 0.0492126 | 677 | -1385.71 |  | 185.713 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1571.43 | 0.0416667 | 3295
714653 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 4486.4 | 0.0492126 | 677 | 200.002 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 95.2045 | 0.0416667 | 3296
714671 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 20320.5 | 0.0656168 | 470 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 323.411 | 0.0625 | 3299
714842 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 27159.6 | 0.0492126 | 688 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 576.344 | 0.0416667 | 3303
714847 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 94244.3 | 0.0656168 | 471 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1499.95 | 0.0625 | 3304
714851 | Level 2 | Piping System: Domestic Hot Water 1 | 4864.67 | Domestic Hot Water 1 | Domestic Hot Water | 26400 | 0.0492126 | 688 | 300 | 0 | 300 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 560.226 | 0.0416667 | 3305
714930 | Level 2 | Piping System: Domestic Hot Water 1 | 3184.29 | Domestic Hot Water 1 | Domestic Hot Water | 78764 | 0.0492126 | 688 | -1385.71 |  | 285.713 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1671.42 | 0.0416667 | 3306
715038 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 28618.4 | 0.0656168 | 469 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 455.476 | 0.0625 | 3310
715158 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 137151 | 0.0656168 | 397 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 2182.83 | 0.0625 | 3311
715164 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 41164 | 0.0656168 | 397 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 655.146 | 0.0625 | 3312
715172 | Level 1 | Piping System: Domestic Hot Water 1 | -232.538 | Domestic Hot Water 1 | Domestic Hot Water | 215832 | 0.0656168 | 397 | 3202.54 |  | -232.538 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 3435.08 | 0.0625 | 3313
715260 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 90573.1 | 0.0492126 | 479 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1922.02 | 0.0416667 | 3314
715267 | Level 2 | Piping System: Domestic Hot Water 1 | 3139.88 | Domestic Hot Water 1 | Domestic Hot Water | 399109 | 0.213255 | 475 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 23716.5 | 0 | 0 | 0 | 0 | 0 | 0.197638 | 65 mmø | 1954.47 | 0.208333 | 3315
715271 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 204585 | 0.0492126 | 479 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 4341.43 | 0.0416667 | 3316
715280 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 4894.09 | 0.0492126 | 479 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 103.856 | 0.0416667 | 3317
715332 | Level 2 | Piping System: Domestic Hot Water 1 | 3184.29 | Domestic Hot Water 1 | Domestic Hot Water | 74051.7 | 0.0492126 | 479 | -1385.71 |  | 185.713 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1571.43 | 0.0416667 | 3318
715336 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 29927 | 0.0492126 | 479 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 635.07 | 0.0416667 | 3319
715391 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 15833.5 | 0.0492126 | 477 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 335.997 | 0.0416667 | 3321
715414 | Level 2 | Piping System: Domestic Hot Water 1 | 3155.76 | Domestic Hot Water 1 | Domestic Hot Water | 98037.2 | 0.104987 | 525 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 975.194 | 0.104167 | 3322
715543 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 114274 | 0.0656168 | 484 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1818.73 | 0.0625 | 3325
715550 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 46115.3 | 0.0656168 | 483 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 733.948 | 0.0625 | 3326
715564 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 89368.1 | 0.0656168 | 503 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1422.34 | 0.0625 | 3327
715587 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 281646 | 0.0656168 | 651 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 4482.54 | 0.0625 | 3329
715593 | Level 2 | Piping System: Domestic Hot Water 1 | 3214.67 | Domestic Hot Water 1 | Domestic Hot Water | 70590.5 | 0.0492126 | 562 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1497.98 | 0.0416667 | 3330
715616 | Level 2 | Piping System: Domestic Hot Water 1 | 3214.67 | Domestic Hot Water 1 | Domestic Hot Water | 2089.86 | 0.0492126 | 562 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 44.3481 | 0.0416667 | 3331
715677 | Level 2 | Piping System: Domestic Hot Water 1 | 3158.72 | Domestic Hot Water 1 | Domestic Hot Water | 34390.4 | 0.082021 | 492 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 437.873 | 0.0833333 | 3334
715695 | Level 2 | Piping System: Domestic Hot Water 1 | 3158.72 | Domestic Hot Water 1 | Domestic Hot Water | 21577.9 | 0.082021 | 486 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 274.739 | 0.0833333 | 3335
715717 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 158496 | 0.0656168 | 679 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 2522.54 | 0.0625 | 3336
715730 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 79018.6 | 0.0656168 | 679 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1257.62 | 0.0625 | 3337
715737 | Level 2 | Piping System: Domestic Hot Water 1 | 4761.89 | Domestic Hot Water 1 | Domestic Hot Water | 4473.87 | 0.0656168 | 679 | 199.994 | 0 | 199.994 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 71.2038 | 0.0625 | 3338
715783 | Level 2 | Piping System: Domestic Hot Water 1 | 3187.46 | Domestic Hot Water 1 | Domestic Hot Water | 98336.6 | 0.0656168 | 679 | -1382.54 |  | 182.538 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1565.08 | 0.0625 | 3339
715803 | Level 2 | Piping System: Domestic Hot Water 1 | 3158.72 | Domestic Hot Water 1 | Domestic Hot Water | 47095.3 | 0.082021 | 492 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 599.636 | 0.0833333 | 3341
715817 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 74096.5 | 0.0492126 | 491 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1572.38 | 0.0416667 | 3342
715824 | Level 2 | Piping System: Domestic Hot Water 1 | 3158.72 | Domestic Hot Water 1 | Domestic Hot Water | 210404 | 0.082021 | 487 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 2678.95 | 0.0833333 | 3343
715828 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 1438.9 | 0.0492126 | 603 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 30.5344 | 0.0416667 | 3344
715980 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 22791.4 | 0.0492126 | 489 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 483.649 | 0.0416667 | 3348
716001 | Level 2 | Piping System: Domestic Hot Water 1 | 3158.72 | Domestic Hot Water 1 | Domestic Hot Water | 105808 | 0.082021 | 493 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 1347.18 | 0.0833333 | 3350
716005 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 124145 | 0.0492126 | 495 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 2634.45 | 0.0416667 | 3351
716037 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 41154 | 0.0492126 | 628 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 873.316 | 0.0416667 | 3352
716230 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 68217.3 | 0.0656168 | 626 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1085.71 | 0.0625 | 3354
716269 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 119522 | 0.0492126 | 498 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 2536.34 | 0.0416667 | 3359
716282 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 2028.47 | 0.0492126 | 498 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 43.0455 | 0.0416667 | 3361
716333 | Level 2 | Piping System: Domestic Hot Water 1 | 3184.29 | Domestic Hot Water 1 | Domestic Hot Water | 74051.7 | 0.0492126 | 498 | -1385.71 |  | 185.713 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1571.43 | 0.0416667 | 3362
716380 | Level 2 | Piping System: Domestic Hot Water 1 | 3193.81 | Domestic Hot Water 1 | Domestic Hot Water | 548.208 | 0.0656168 | 503 | -1376.19 |  | -1367.46 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 8.725 | 0.0625 | 3365
716382 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 4684.28 | 0.0656168 | 499 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 74.5526 | 0.0625 | 3366
716446 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 17044.1 | 0.0656168 | 500 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 271.266 | 0.0625 | 3367
716530 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 41395.5 | 0.0492126 | 625 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 878.441 | 0.0416667 | 3369
716537 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 72866.3 | 0.0656168 | 623 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1159.7 | 0.0625 | 3370
716622 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 49477.8 | 0.0656168 | 508 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 787.464 | 0.0625 | 3375
716629 | Level 2 | Piping System: Domestic Hot Water 1 | 3158.72 | Domestic Hot Water 1 | Domestic Hot Water | 43424.5 | 0.082021 | 504 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 552.897 | 0.0833333 | 3376
716633 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 1995.22 | 0.0656168 | 508 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 31.755 | 0.0625 | 3377
716712 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 29905.1 | 0.0656168 | 506 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 475.955 | 0.0625 | 3378
716748 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 93911.8 | 0.0492126 | 654 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1992.87 | 0.0416667 | 3379
716755 | Level 2 | Piping System: Domestic Hot Water 1 | 3158.72 | Domestic Hot Water 1 | Domestic Hot Water | 105868 | 0.082021 | 509 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 1347.96 | 0.0833333 | 3380
716759 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 2014.67 | 0.0492126 | 654 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 42.7526 | 0.0416667 | 3381
716840 | Level 2 | Piping System: Domestic Hot Water 1 | 3184.29 | Domestic Hot Water 1 | Domestic Hot Water | 74051.7 | 0.0492126 | 654 | -1385.71 |  | 185.713 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1571.43 | 0.0416667 | 3382
716921 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 22428.8 | 0.0492126 | 511 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 475.955 | 0.0416667 | 3385
716947 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 180090 | 0.0492126 | 655 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 3821.63 | 0.0416667 | 3386
716958 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 30234.3 | 0.0492126 | 655 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 641.592 | 0.0416667 | 3388
717035 | Level 2 | Piping System: Domestic Hot Water 1 | 3184.29 | Domestic Hot Water 1 | Domestic Hot Water | 74051.7 | 0.0492126 | 655 | -1385.71 |  | 185.713 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1571.43 | 0.0416667 | 3389
717104 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 24223.1 | 0.0492126 | 638 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 514.031 | 0.0416667 | 3392
717130 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 55171.7 | 0.0492126 | 513 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1170.78 | 0.0416667 | 3393
717137 | Level 2 | Piping System: Domestic Hot Water 1 | 3155.76 | Domestic Hot Water 1 | Domestic Hot Water | 171280 | 0.104987 | 630 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 1703.76 | 0.104167 | 3394
717141 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 22686.6 | 0.0492126 | 513 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 481.425 | 0.0416667 | 3395
717146 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 2568.26 | 0.0492126 | 513 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 54.5001 | 0.0416667 | 3396
717184 | Level 2 | Piping System: Domestic Hot Water 1 | 3184.29 | Domestic Hot Water 1 | Domestic Hot Water | 74051.7 | 0.0492126 | 513 | -1385.71 |  | 185.713 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1571.43 | 0.0416667 | 3397
717225 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 25824.2 | 0.0492126 | 634 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 548.008 | 0.0416667 | 3400
717248 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 72363.1 | 0.0492126 | 518 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1535.59 | 0.0416667 | 3401
717255 | Level 2 | Piping System: Domestic Hot Water 1 | 3155.76 | Domestic Hot Water 1 | Domestic Hot Water | 163707 | 0.104987 | 482 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 1628.43 | 0.104167 | 3402
717259 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 25749.7 | 0.0492126 | 518 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 546.425 | 0.0416667 | 3403
717264 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 1332.85 | 0.0492126 | 518 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 28.284 | 0.0416667 | 3404
717304 | Level 2 | Piping System: Domestic Hot Water 1 | 3184.29 | Domestic Hot Water 1 | Domestic Hot Water | 74051.7 | 0.0492126 | 518 | -1385.71 |  | 185.713 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1571.43 | 0.0416667 | 3405
717361 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 24005.4 | 0.0492126 | 516 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 509.41 | 0.0416667 | 3408
717375 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 85779.8 | 0.0492126 | 523 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1820.3 | 0.0416667 | 3409
717382 | Level 2 | Piping System: Domestic Hot Water 1 | 3155.76 | Domestic Hot Water 1 | Domestic Hot Water | 277147 | 0.104987 | 514 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 2756.83 | 0.104167 | 3410
717386 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 34467.6 | 0.0492126 | 523 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 731.425 | 0.0416667 | 3411
717391 | Level 2 | Piping System: Domestic Hot Water 1 | 4664.67 | Domestic Hot Water 1 | Domestic Hot Water | 12387.6 | 0.0492126 | 523 | 100 | 0 | 100 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 262.872 | 0.0416667 | 3412
717445 | Level 2 | Piping System: Domestic Hot Water 1 | 3184.29 | Domestic Hot Water 1 | Domestic Hot Water | 69339.3 | 0.0492126 | 523 | -1385.71 |  | 85.7125 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1471.42 | 0.0416667 | 3413
717495 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 23095.9 | 0.0492126 | 521 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 490.111 | 0.0416667 | 3416
717563 | Level 2 | Piping System: Domestic Hot Water 1 | 3158.72 | Domestic Hot Water 1 | Domestic Hot Water | 16395.8 | 0.082021 | 546 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 208.758 | 0.0833333 | 3417
717582 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 87167.2 | 0.0492126 | 26 | -1400 | 0 | -1400 | Level: Level 2 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 5342.42 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 1849.74 | 0.0416667 | 3418
717589 | Level 2 | Piping System: Domestic Hot Water 1 | 3155.76 | Domestic Hot Water 1 | Domestic Hot Water | 158508 | 0.104987 | 519 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 1576.71 | 0.104167 | 3419
717593 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 66348.8 | 0.0492126 | 26 | -1400 | 0 | -1400 | Level: Level 2 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 4066.48 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 1407.97 | 0.0416667 | 3420
717598 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 19526.1 | 0.0492126 | 26 | 200 | 0 | 200 | Level: Level 2 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 1196.74 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 414.357 | 0.0416667 | 3421
717640 | Level 2 | Piping System: Domestic Hot Water 1 | 3184.29 | Domestic Hot Water 1 | Domestic Hot Water | 74051.7 | 0.0492126 | 26 | -1385.71 |  | 185.713 | Level: Level 2 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 4538.58 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 1571.43 | 0.0416667 | 3422
717696 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 21782.5 | 0.0492126 | 28 | -1400 | 0 | -1400 | Level: Level 2 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 1335.04 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 462.239 | 0.0416667 | 3423
717717 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 70609.2 | 0.0492126 | 529 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1498.37 | 0.0416667 | 3424
717724 | Level 2 | Piping System: Domestic Hot Water 1 | 3155.76 | Domestic Hot Water 1 | Domestic Hot Water | 173662 | 0.104987 | 524 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 1727.45 | 0.104167 | 3425
717728 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 36304.8 | 0.0492126 | 529 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 770.412 | 0.0416667 | 3426
717733 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 615.258 | 0.0492126 | 529 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 13.0562 | 0.0416667 | 3427
717778 | Level 2 | Piping System: Domestic Hot Water 1 | 3184.29 | Domestic Hot Water 1 | Domestic Hot Water | 74051.7 | 0.0492126 | 529 | -1385.71 |  | 185.713 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1571.43 | 0.0416667 | 3428
717824 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 24005.4 | 0.0492126 | 527 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 509.41 | 0.0416667 | 3431
717862 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 177493 | 0.0656168 | 676 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 2824.89 | 0.0625 | 3432
717869 | Level 2 | Piping System: Domestic Hot Water 1 | 3158.72 | Domestic Hot Water 1 | Domestic Hot Water | 158719 | 0.082021 | 530 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 2020.87 | 0.0833333 | 3433
717873 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 4201.84 | 0.0656168 | 676 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 66.8744 | 0.0625 | 3434
717878 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 217403 | 0.0656168 | 676 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 3460.08 | 0.0625 | 3435
718410 | Level 2 | Piping System: Domestic Hot Water 1 | 4761.9 | Domestic Hot Water 1 | Domestic Hot Water | 3777.74 | 0.0656168 | 676 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 60.1245 | 0.0625 | 3436
718417 | Level 2 | Piping System: Domestic Hot Water 1 | 3187.46 | Domestic Hot Water 1 | Domestic Hot Water | 98336.6 | 0.0656168 | 676 | -1382.54 |  | 182.538 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1565.08 | 0.0625 | 3437
718430 | Level 2 | Piping System: Domestic Hot Water 1 | 4761.9 | Domestic Hot Water 1 | Domestic Hot Water | 4535.91 | 0.0656168 | 686 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 72.1912 | 0.0625 | 3439
718437 | Level 2 | Piping System: Domestic Hot Water 1 | 3193.81 | Domestic Hot Water 1 | Domestic Hot Water | 97937.6 | 0.0656168 | 686 | -1376.19 |  | 182.538 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1558.73 | 0.0625 | 3440
718439 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 224901 | 0.0656168 | 535 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 3579.41 | 0.0625 | 3441
718491 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 34192.9 | 0.0656168 | 533 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 544.197 | 0.0625 | 3443
718533 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 64004 | 0.0492126 | 540 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1358.21 | 0.0416667 | 3444
718540 | Level 2 | Piping System: Domestic Hot Water 1 | 3158.72 | Domestic Hot Water 1 | Domestic Hot Water | 75661.8 | 0.082021 | 531 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 963.356 | 0.0833333 | 3445
718544 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 65333.7 | 0.0492126 | 540 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1386.43 | 0.0416667 | 3446
718558 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 971.93 | 0.0492126 | 540 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 20.625 | 0.0416667 | 3447
718585 | Level 2 | Piping System: Domestic Hot Water 1 | 3184.29 | Domestic Hot Water 1 | Domestic Hot Water | 74051.7 | 0.0492126 | 540 | -1385.71 |  | 185.713 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1571.43 | 0.0416667 | 3448
718618 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 18812.6 | 0.0492126 | 538 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 399.216 | 0.0416667 | 3451
718662 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 75079.3 | 0.0492126 | 545 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1593.23 | 0.0416667 | 3452
718669 | Level 2 | Piping System: Domestic Hot Water 1 | 3158.72 | Domestic Hot Water 1 | Domestic Hot Water | 241576 | 0.082021 | 536 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 3075.85 | 0.0833333 | 3453
718687 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 56615.8 | 0.0492126 | 545 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1201.43 | 0.0416667 | 3454
718696 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 1960.17 | 0.0492126 | 545 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 41.5962 | 0.0416667 | 3455
718752 | Level 2 | Piping System: Domestic Hot Water 1 | 3184.29 | Domestic Hot Water 1 | Domestic Hot Water | 74051.7 | 0.0492126 | 545 | -1385.71 |  | 185.713 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1571.43 | 0.0416667 | 3456
718786 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 20886.3 | 0.0492126 | 543 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 443.222 | 0.0416667 | 3459
718855 | Level 2 | Piping System: Domestic Hot Water 1 | 3111.9 | Domestic Hot Water 1 | Domestic Hot Water | 14772.7 | 0.0656168 | 563 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 235.115 | 0.0625 | 3460
718871 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 143534 | 0.0492126 | 550 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 3045.88 | 0.0416667 | 3461
718878 | Level 2 | Piping System: Domestic Hot Water 1 | 3158.72 | Domestic Hot Water 1 | Domestic Hot Water | 445892 | 0.082021 | 541 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 5677.27 | 0.0833333 | 3462
718882 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 42949.9 | 0.0492126 | 550 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 911.425 | 0.0416667 | 3463
718887 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 2861.51 | 0.0492126 | 550 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 60.7231 | 0.0416667 | 3464
718928 | Level 2 | Piping System: Domestic Hot Water 1 | 3184.29 | Domestic Hot Water 1 | Domestic Hot Water | 74051.7 | 0.0492126 | 550 | -1385.71 |  | 185.713 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1571.43 | 0.0416667 | 3465
718979 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 20844.5 | 0.0492126 | 548 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 442.334 | 0.0416667 | 3468
718993 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 92110.2 | 0.0492126 | 555 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1954.64 | 0.0416667 | 3469
719000 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 13431.4 | 0.0656168 | 650 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 213.768 | 0.0625 | 3470
719004 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 11842.7 | 0.0492126 | 555 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 251.31 | 0.0416667 | 3471
719070 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 19037.1 | 0.0492126 | 553 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 403.979 | 0.0416667 | 3473
719106 | Level 2 | Piping System: Domestic Hot Water 1 | 3214.67 | Domestic Hot Water 1 | Domestic Hot Water | 32288.2 | 0.0492126 | 556 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 685.178 | 0.0416667 | 3474
719185 | Level 2 | Piping System: Domestic Hot Water 1 | 3114.67 | Domestic Hot Water 1 | Domestic Hot Water | 34778 | 0.0492126 | 557 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 738.013 | 0.0416667 | 3475
719193 | Level 2 | Piping System: Domestic Hot Water 1 | 3114.67 | Domestic Hot Water 1 | Domestic Hot Water | 4583.98 | 0.0492126 | 614 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 97.275 | 0.0416667 | 3476
719198 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 2833.32 | 0.0492126 | 614 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 60.125 | 0.0416667 | 3477
719240 | Level 2 | Piping System: Domestic Hot Water 1 | 3134.29 | Domestic Hot Water 1 | Domestic Hot Water | 76407.9 | 0.0492126 | 614 | -1435.71 |  | 185.713 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1621.43 | 0.0416667 | 3478
719285 | Level 2 | Piping System: Domestic Hot Water 1 | 3114.67 | Domestic Hot Water 1 | Domestic Hot Water | 750.07 | 0.0492126 | 562 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 15.917 | 0.0416667 | 3481
719358 | Level 2 | Piping System: Domestic Hot Water 1 | 3134.29 | Domestic Hot Water 1 | Domestic Hot Water | 3365.82 | 0.0492126 | 562 | -1364.29 |  | -1435.71 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 71.425 | 0.0416667 | 3482
719387 | Level 2 | Piping System: Domestic Hot Water 1 | 3114.67 | Domestic Hot Water 1 | Domestic Hot Water | 41689.3 | 0.0492126 | 561 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 884.674 | 0.0416667 | 3484
719396 | Level 2 | Piping System: Domestic Hot Water 1 | 3114.67 | Domestic Hot Water 1 | Domestic Hot Water | 93957.7 | 0.0492126 | 567 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1993.84 | 0.0416667 | 3485
719403 | Level 2 | Piping System: Domestic Hot Water 1 | 3111.9 | Domestic Hot Water 1 | Domestic Hot Water | 75557.7 | 0.0656168 | 551 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1202.54 | 0.0625 | 3486
719407 | Level 2 | Piping System: Domestic Hot Water 1 | 3114.67 | Domestic Hot Water 1 | Domestic Hot Water | 24798.3 | 0.0492126 | 567 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 526.236 | 0.0416667 | 3487
719522 | Level 2 | Piping System: Domestic Hot Water 1 | 3114.67 | Domestic Hot Water 1 | Domestic Hot Water | 18995.2 | 0.0492126 | 565 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 403.092 | 0.0416667 | 3492
719651 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 46278.3 | 0.0492126 | 678 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 982.056 | 0.0416667 | 3494
719658 | Level 2 | Piping System: Domestic Hot Water 1 | 3152.58 | Domestic Hot Water 1 | Domestic Hot Water | 246159 | 0.131234 | 568 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 1958.87 | 0.125 | 3495
719662 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 1554.6 | 0.0492126 | 678 | 200 | 0 | 200.001 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 32.9897 | 0.0416667 | 3496
719713 | Level 2 | Piping System: Domestic Hot Water 1 | 3184.29 | Domestic Hot Water 1 | Domestic Hot Water | 74051.7 | 0.0492126 | 678 | -1385.71 |  | 185.713 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1571.43 | 0.0416667 | 3497
719717 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 4631.62 | 0.0492126 | 678 | 200.001 | 0 | 200.001 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 98.2861 | 0.0416667 | 3498
1054435 | Level 2 | Piping System: Domestic Hot Water 1 | 3139.88 | Domestic Hot Water 1 | Domestic Hot Water | 1387.51 | 0.213255 | 5 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 23716.5 | 0 | 0 | 0 | 0 | 0 | 0.197638 | 65 mmø | 6.79474 | 0.208333 | 4979
1054664 | Level 2 | Piping System: Domestic Hot Water 1 | 3139.88 | Domestic Hot Water 1 | Domestic Hot Water | 20913.4 | 0.213255 | 5 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 23716.5 | 0 | 0 | 0 | 0 | 0 | 0.197638 | 65 mmø | 102.415 | 0.208333 | 4988
1054768 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 624860 | 0.0656168 | 454 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 9944.96 | 0.0625 | 4990
1060903 | Level 2 | Piping System: Domestic Hot Water 1 | 3139.88 | Domestic Hot Water 1 | Domestic Hot Water | 1973204 | 0.213255 | 462 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 23716.5 | 0 | 0 | 0 | 0 | 0 | 0.197638 | 65 mmø | 9662.93 | 0.208333 | 4996
1061421 | Level 2 | Piping System: Domestic Hot Water 1 | 3139.88 | Domestic Hot Water 1 | Domestic Hot Water | 67594 | 0.213255 | 5 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 23716.5 | 0 | 0 | 0 | 0 | 0 | 0.197638 | 65 mmø | 331.013 | 0.208333 | 4997
1076375 | Level 1 | Piping System: Domestic Hot Water 1 | 214.286 | Domestic Hot Water 1 | Domestic Hot Water | 27875.9 | 0.0492126 | 571 | 214.288 | 4462.96 | 805.833 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 591.545 | 0.0416667 | 5125
1076378 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 3612.67 | 0.0492126 | 571 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 76.6632 | 0.0416667 | 5126
1076754 | Level 1 | Piping System: Domestic Hot Water 1 | 214.283 | Domestic Hot Water 1 | Domestic Hot Water | 27875.9 | 0.0492126 | 403 | 214.287 | 1253.34 | 805.833 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 591.545 | 0.0416667 | 5128
1077228 | Level 1 | Piping System: Domestic Hot Water 1 | 214.285 | Domestic Hot Water 1 | Domestic Hot Water | 27875.9 | 0.0492126 | 575 | 214.287 | 2232.33 | 805.833 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 591.546 | 0.0416667 | 5135
1077229 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 1594.58 | 0.0492126 | 575 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 33.8381 | 0.0416667 | 5136
1077343 | Level 1 | Piping System: Domestic Hot Water 1 | 214.288 | Domestic Hot Water 1 | Domestic Hot Water | 27875.9 | 0.0492126 | 576 | 214.288 |  | 805.833 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 591.545 | 0.0416667 | 5138
1077344 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 4006.67 | 0.0492126 | 576 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 85.0241 | 0.0416667 | 5139
1077608 | Level 1 | Piping System: Domestic Hot Water 1 | 214.288 | Domestic Hot Water 1 | Domestic Hot Water | 27875.9 | 0.0492126 | 371 | 214.288 |  | 805.833 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 591.545 | 0.0416667 | 5147
1077609 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 5561.8 | 0.0492126 | 371 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 118.025 | 0.0416667 | 5148
1077939 | Level 1 | Piping System: Domestic Hot Water 1 | 214.285 | Domestic Hot Water 1 | Domestic Hot Water | 27875.9 | 0.0492126 | 580 | 214.288 | 2231.26 | 805.833 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 591.545 | 0.0416667 | 5151
1077940 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 4058.5 | 0.0492126 | 580 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 86.1241 | 0.0416667 | 5152
1078057 | Level 1 | Piping System: Domestic Hot Water 1 | 214.287 | Domestic Hot Water 1 | Domestic Hot Water | 27875.9 | 0.0492126 | 581 | 805.833 |  | 214.287 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 591.545 | 0.0416667 | 5157
1078058 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 4003.58 | 0.0492126 | 581 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 84.9586 | 0.0416667 | 5158
1078306 | Level 1 | Piping System: Domestic Hot Water 1 | -285.712 | Domestic Hot Water 1 | Domestic Hot Water | 51437.8 | 0.0492126 | 315 | -285.712 | 29839.8 | 805.833 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1091.54 | 0.0416667 | 5162
1078307 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 5086.02 | 0.0492126 | 315 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 107.929 | 0.0416667 | 5163
1078510 | Level 1 | Piping System: Domestic Hot Water 1 | 314.286 | Domestic Hot Water 1 | Domestic Hot Water | 23163.5 | 0.0492126 | 298 | 314.289 | 1851 | 805.833 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 491.544 | 0.0416667 | 5169
