Properties of the parts of a building model (IFC2X3), part 13 of 29

# IfcFlowFitting: Transition - Generic (1079)
Name (M_Transition - Generic:Transition - Generic:Transition - Generic:...) | In | Fitting Outside Radius 1 = Insulation Radius 1 | Width Offset | Visibility 3 | Visibility 1 | Max Fitting Outside Diameter 12 | Visibility 2 | Fitting Outside Radius 2 = Insulation Radius 2 | Height Offset | System Name | System Classification | System Type | Loss Method | Offset (mm) | Level | Host | Mark | Fitting Outside Diameter 2 | OffsetHeight | Length | Nominal Radius 1 | OffsetWidth | Nominal Radius 2 | Tick Size 2 | Tick Size 1 | Fitting Outside Diameter 1 | Size = Overall Size | Nominal Diameter 1 | Nominal Diameter 2
682305 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 371.263 | Level: Level 1 | Level : Level 1 | 5348 | 0.0520833 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0246063 | 0.0208333 | 0.0541667 | 0.135417 | 40 mmø-15 mmø | 0.131234 | 0.0492126
682537 | TOF Footing | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5356 | 0.0520833 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0246063 | 0.0208333 | 0.0875 | 0.21875 | 65 mmø-15 mmø | 0.213255 | 0.0492126
682644 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5371 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
682645 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5372 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
682681 | TOF Footing | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5376 | 0.135417 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0656168 | 0.0541667 | 0.0875 | 0.21875 | 65 mmø-40 mmø | 0.213255 | 0.131234
682763 | Level 1 | 0.0677083 | 10.0217 | no | no | 0.135417 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 657.288 | Level: Level 1 | Level : Level 1 | 5388 | 0.09375 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0873664 | 0.0410105 | 0.0375 | 0.0541667 | 0.135417 | 40 mmø-25 mmø | 0.131234 | 0.082021
682788 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 371.263 | Level: Level 1 | Level : Level 1 | 5393 | 0.0520833 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0246063 | 0.0208333 | 0.0541667 | 0.135417 | 40 mmø-15 mmø | 0.131234 | 0.0492126
682823 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5399 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
682824 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5400 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
683401 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -434.912 | Level: Level 1 | Level : Level 1 | 5410 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
683554 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -500 | Level: Level 1 | Level : Level 1 | 5435 | 0.114583 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0524934 | 0.0458333 | 0.1375 | 0.34375 | 100 mmø-32 mmø | 0.328084 | 0.104987
683565 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5439 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
683637 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 657.288 | Level: Level 1 | Level : Level 1 | 5452 | 0.09375 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0410105 | 0.0375 | 0.0541667 | 0.135417 | 40 mmø-25 mmø | 0.131234 | 0.082021
683655 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 371.263 | Level: Level 1 | Level : Level 1 | 5458 | 0.0520833 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0246063 | 0.0208333 | 0.0541667 | 0.135417 | 40 mmø-15 mmø | 0.131234 | 0.0492126
683690 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5463 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
683691 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5464 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
683830 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5468 | 0.09375 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0410105 | 0.0375 | 0.1375 | 0.34375 | 100 mmø-25 mmø | 0.328084 | 0.082021
683842 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5471 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
683966 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5492 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
683997 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5497 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
684111 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5513 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
684112 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5514 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
684239 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 728.919 | Level: Level 1 | Level : Level 1 | 5527 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
684430 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5547 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
684543 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 786.419 | Level: Level 1 | Level : Level 1 | 5563 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
684583 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5569 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
684584 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5570 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
684616 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5574 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
684740 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5591 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
684741 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5592 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
684796 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5596 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
684877 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 691.419 | Level: Level 1 | Level : Level 1 | 5610 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
684896 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 748.741 | Level: Level 1 | Level : Level 1 | 5618 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
684940 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5624 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
684941 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5625 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
684973 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5629 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
685107 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5652 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
685108 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5653 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
685177 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5659 | 0.0520833 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0246063 | 0.0208333 | 0.1375 | 0.34375 | 100 mmø-15 mmø | 0.328084 | 0.0492126
685404 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5670 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
685405 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5671 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
685458 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5675 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
685551 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 721.656 | Level: Level 1 | Level : Level 1 | 5686 | 0.0520833 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0246063 | 0.0208333 | 0.0541667 | 0.135417 | 40 mmø-15 mmø | 0.131234 | 0.0492126
685586 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5691 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
685671 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.109375 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5706 | 0.21875 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.106627 | 0.0875 | 0.1375 | 0.34375 | 100 mmø-65 mmø | 0.328084 | 0.213255
685694 | TOF Footing | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0885417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5713 | 0.177083 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.082021 | 0.0708333 | 0.0875 | 0.21875 | 65 mmø-50 mmø | 0.213255 | 0.164042
685865 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 688.244 | Level: Level 1 | Level : Level 1 | 5737 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
685884 | Level 1 | 0.046875 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 688.244 | Level: Level 1 | Level : Level 1 | 5744 | 0.177083 | 0.0410105 | 0.0442708 | 0.0410105 | 0.0410105 | 0.082021 | 0.0708333 | 0.0375 | 0.09375 | 50 mmø-25 mmø | 0.082021 | 0.164042
685977 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5752 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
686067 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 657.288 | Level: Level 1 | Level : Level 1 | 5767 | 0.09375 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0410105 | 0.0375 | 0.0541667 | 0.135417 | 40 mmø-25 mmø | 0.131234 | 0.082021
686368 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 975.394 | Level: Level 1 | Level : Level 1 | 5782 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
686394 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5788 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
686501 | TOF Footing | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0885417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5802 | 0.177083 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.082021 | 0.0708333 | 0.0875 | 0.21875 | 65 mmø-50 mmø | 0.213255 | 0.164042
686520 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5808 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
686668 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 343.481 | Level: Level 1 | Level : Level 1 | 5822 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
686724 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5831 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
686832 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5848 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
686833 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5849 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
686875 | TOF Footing | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5853 | 0.0520833 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0246063 | 0.0208333 | 0.0875 | 0.21875 | 65 mmø-15 mmø | 0.213255 | 0.0492126
686956 | TOF Footing | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5864 | 0.0520833 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0246063 | 0.0208333 | 0.0875 | 0.21875 | 65 mmø-15 mmø | 0.213255 | 0.0492126
687073 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5880 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
687074 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5881 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
687174 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5882 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
687175 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5883 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
687199 | TOF Footing | 0.109375 | 10 | no | no | 0.21875 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5887 | 0.09375 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0410105 | 0.0375 | 0.0875 | 0.21875 | 65 mmø-25 mmø | 0.213255 | 0.082021
687651 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 600 | Level: Level 1 | Level : Level 1 | 5944 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
687699 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -501.123 | Level: Level 1 | Level : Level 1 | 5953 | 0.114583 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0524934 | 0.0458333 | 0.1375 | 0.34375 | 100 mmø-32 mmø | 0.328084 | 0.104987
687729 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5956 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
687730 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5957 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
687762 | TOF Footing | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5961 | 0.0729167 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0328084 | 0.0291667 | 0.0875 | 0.21875 | 65 mmø-20 mmø | 0.213255 | 0.0656168
687871 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 656.419 | Level: Level 1 | Level : Level 1 | 5975 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
687893 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5976 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
687894 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5977 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
687916 | TOF Footing | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 5981 | 0.0729167 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0328084 | 0.0291667 | 0.0875 | 0.21875 | 65 mmø-20 mmø | 0.213255 | 0.0656168
687978 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 708.919 | Level: Level 1 | Level : Level 1 | 5988 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
688079 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 705.387 | Level: Level 1 | Level : Level 1 | 6000 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
688109 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6006 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
688110 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6007 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
688132 | TOF Footing | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6011 | 0.0520833 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0246063 | 0.0208333 | 0.0875 | 0.21875 | 65 mmø-15 mmø | 0.213255 | 0.0492126
688240 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6019 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
688241 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6020 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
688265 | TOF Footing | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6024 | 0.0729167 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0328084 | 0.0291667 | 0.0875 | 0.21875 | 65 mmø-20 mmø | 0.213255 | 0.0656168
688417 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 726.419 | Level: Level 1 | Level : Level 1 | 6044 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
688436 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 746.419 | Level: Level 1 | Level : Level 1 | 6052 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
688482 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6058 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
688483 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6059 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
688524 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6063 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
688656 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6074 | 0.0729167 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0328084 | 0.0291667 | 0.1375 | 0.34375 | 100 mmø-20 mmø | 0.328084 | 0.0656168
688729 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 751.419 | Level: Level 1 | Level : Level 1 | 6085 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
688757 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 751.419 | Level: Level 1 | Level : Level 1 | 6098 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
688827 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6099 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
688828 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6100 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
688857 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6104 | 0.0520833 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0246063 | 0.0208333 | 0.1375 | 0.34375 | 100 mmø-15 mmø | 0.328084 | 0.0492126
688998 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6126 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
688999 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6127 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
689024 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6131 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
689105 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 657.288 | Level: Level 1 | Level : Level 1 | 6142 | 0.09375 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0410105 | 0.0375 | 0.0541667 | 0.135417 | 40 mmø-25 mmø | 0.131234 | 0.082021
689192 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 500 | Level: Level 1 | Level : Level 1 | 6157 | 0.0520833 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0246063 | 0.0208333 | 0.0541667 | 0.135417 | 40 mmø-15 mmø | 0.131234 | 0.0492126
689221 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6158 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
689222 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6159 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
689256 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6163 | 0.09375 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0410105 | 0.0375 | 0.1375 | 0.34375 | 100 mmø-25 mmø | 0.328084 | 0.082021
689346 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6169 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
689347 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6170 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
689383 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6174 | 0.0729167 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0328084 | 0.0291667 | 0.1375 | 0.34375 | 100 mmø-20 mmø | 0.328084 | 0.0656168
689459 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6180 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
689460 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6181 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
689550 | TOF Footing | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6185 | 0.0520833 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0246063 | 0.0208333 | 0.0541667 | 0.135417 | 40 mmø-15 mmø | 0.131234 | 0.0492126
689754 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6201 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
689755 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6202 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
689802 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6203 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
689803 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6204 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
689849 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6208 | 0.09375 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0410105 | 0.0375 | 0.1375 | 0.34375 | 100 mmø-25 mmø | 0.328084 | 0.082021
689891 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6211 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
689920 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6220 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
690003 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6235 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
690004 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6236 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
690026 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6240 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
690128 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6254 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
690129 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6255 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
690169 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6259 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
690252 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6271 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
690253 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6272 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
690362 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6281 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
690434 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6286 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
690484 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6290 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
690485 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6291 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
690507 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6295 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
690638 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6310 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
690917 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 657.288 | Level: Level 1 | Level : Level 1 | 6337 | 0.09375 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0410105 | 0.0375 | 0.0541667 | 0.135417 | 40 mmø-25 mmø | 0.131234 | 0.082021
690945 | TOF Footing | 0.109375 | 10 | no | no | 0.21875 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6341 | 0.09375 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0410105 | 0.0375 | 0.0875 | 0.21875 | 65 mmø-25 mmø | 0.213255 | 0.082021
690997 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6355 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
691014 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6361 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
691095 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6379 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
691191 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6397 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
691335 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6422 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
691435 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6435 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
691436 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 6436 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
692167 | Level 2 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 6463 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
692193 | Level 2 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 6478 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
692214 | Level 2 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 6488 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
692405 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -411 | Level: Level 2 | Level : Level 2 | 6507 | 0.114583 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0524934 | 0.0458333 | 0.1375 | 0.34375 | 100 mmø-32 mmø | 0.328084 | 0.104987
692406 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -411 | Level: Level 2 | Level : Level 2 | 6508 | 0.114583 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0524934 | 0.0458333 | 0.1375 | 0.34375 | 100 mmø-32 mmø | 0.328084 | 0.104987
692438 | Level 2 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 239.688 | Level: Level 2 | Level : Level 2 | 6518 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
692584 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6522 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
692709 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6541 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
692896 | Level 2 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 298.02 | Level: Level 2 | Level : Level 2 | 6561 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
692951 | Level 2 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 6566 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
692983 | Level 2 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 6583 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
693010 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6588 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
693255 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6606 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
693506 | Level 2 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 300 | Level: Level 2 | Level : Level 2 | 6625 | 0.0520833 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0246063 | 0.0208333 | 0.0541667 | 0.135417 | 40 mmø-15 mmø | 0.131234 | 0.0492126
693527 | Level 2 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 300 | Level: Level 2 | Level : Level 2 | 6628 | 0.09375 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0410105 | 0.0375 | 0.0541667 | 0.135417 | 40 mmø-25 mmø | 0.131234 | 0.082021
693702 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6634 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
693703 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6635 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
694022 | Level 1 | 0.046875 | 10 | yes | no | 0.114583 | no | 0.0572917 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6643 | 0.114583 | 0.0410105 | 0.0286458 | 0.0410105 | 0.0410105 | 0.0524934 | 0.0458333 | 0.0375 | 0.09375 | 32 mmø-25 mmø | 0.082021 | 0.104987
694052 | Level 1 | 0.0572917 | 10 | yes | no | 0.21875 | no | 0.109375 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6651 | 0.21875 | 0.0524934 | 0.0546875 | 0.0524934 | 0.0524934 | 0.106627 | 0.0875 | 0.0458333 | 0.114583 | 65 mmø-32 mmø | 0.104987 | 0.213255
694091 | Level 1 | 0.109375 | 10 | no | no | 0.21875 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6664 | 0.09375 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0410105 | 0.0375 | 0.0875 | 0.21875 | 65 mmø-25 mmø | 0.213255 | 0.082021
694117 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6673 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
694246 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6688 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
694247 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6689 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
694295 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6697 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
694546 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6707 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
694547 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6708 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
694578 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6712 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
