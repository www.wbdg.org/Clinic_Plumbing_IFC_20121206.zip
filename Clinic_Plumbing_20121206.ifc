Properties of the parts of a building model (IFC2X3), part 22 of 29

# IfcFlowSegment: Pipe Types:Hot Water:699832 (871)
Name (Pipe Types:Hot Water:...) | In | System Type | Invert Elevation (mm) | System Name | System Classification | Area (mm2) | Diameter | Section | Offset (mm) = Start Offset (mm) | Slope | End Offset (mm) | Reference Level | Reynolds Number | Flow State | Friction | Relative Roughness | Velocity | Friction Factor | Pressure Drop | Fixture Units | Flow | Inner Diameter | Size = Overall Size | Length (mm) | Outer Diameter | Mark
700646 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 2692.11 | 0.0492126 | 246 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 57.1283 | 0.0416667 | 2664
700653 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 246 | -285.713 |  | 185.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 2665
700689 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 26351 | 0.0492126 | 244 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 559.185 | 0.0416667 | 2668
700748 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 19720.1 | 0.0656168 | 251 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 313.855 | 0.0625 | 2669
700755 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 227039 | 0.082021 | 247 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 2890.75 | 0.0833333 | 2670
700759 | Level 1 | Piping System: Domestic Hot Water 1 | 291.895 | Domestic Hot Water 1 | Domestic Hot Water | 5322.64 | 0.0656168 | 132 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 84.7124 | 0.0625 | 2671
700874 | Level 1 | Piping System: Domestic Hot Water 1 | -282.538 | Domestic Hot Water 1 | Domestic Hot Water | 35504.7 | 0.0656168 | 251 | -282.538 |  | 282.538 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 565.075 | 0.0625 | 2672
700879 | Level 1 | Piping System: Domestic Hot Water 1 | 291.895 | Domestic Hot Water 1 | Domestic Hot Water | 15546.5 | 0.0656168 | 132 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 247.43 | 0.0625 | 2673
700885 | Level 1 | Piping System: Domestic Hot Water 1 | 323.021 | Domestic Hot Water 1 | Domestic Hot Water | 22393.3 | 0.0492126 | 131 | 323.022 | 5783.52 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 475.202 | 0.0416667 | 2674
700889 | Level 1 | Piping System: Domestic Hot Water 1 | 291.895 | Domestic Hot Water 1 | Domestic Hot Water | 8329.21 | 0.0656168 | 129 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 132.564 | 0.0625 | 2675
700897 | Level 1 | Piping System: Domestic Hot Water 1 | 323.021 | Domestic Hot Water 1 | Domestic Hot Water | 22393.3 | 0.0492126 | 128 | 323.022 | 4352.07 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 475.202 | 0.0416667 | 2677
700902 | Level 1 | Piping System: Domestic Hot Water 1 | 291.895 | Domestic Hot Water 1 | Domestic Hot Water | 66824.3 | 0.0656168 | 251 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1063.54 | 0.0625 | 2678
701198 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 33732.1 | 0.0656168 | 249 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 536.863 | 0.0625 | 2699
701343 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 3649.94 | 0.104987 | 271 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 36.3066 | 0.104167 | 2701
701353 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 169931 | 0.082021 | 255 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 2163.63 | 0.0833333 | 2702
701414 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 68670 | 0.0492126 | 123 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1457.22 | 0.0416667 | 2703
701421 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 65906 | 0.082021 | 256 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 839.141 | 0.0833333 | 2704
701425 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 61799.4 | 0.0492126 | 123 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1311.43 | 0.0416667 | 2705
701430 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 2663.38 | 0.0492126 | 123 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 56.5187 | 0.0416667 | 2706
701503 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 26927.8 | 0.0492126 | 123 | -285.713 |  | 285.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 571.425 | 0.0416667 | 2707
701507 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 5815.51 | 0.0492126 | 123 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 123.409 | 0.0416667 | 2708
701518 | Level 1 | Piping System: Domestic Hot Water 1 | 314.287 | Domestic Hot Water 1 | Domestic Hot Water | 22804.9 | 0.0492126 | 123 | 314.287 | 6606.48 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 483.936 | 0.0416667 | 2709
701544 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 28715.9 | 0.0492126 | 125 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 609.371 | 0.0416667 | 2710
701565 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 475835 | 0.082021 | 257 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 6058.51 | 0.0833333 | 2712
701569 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 18367.1 | 0.0492126 | 261 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 389.761 | 0.0416667 | 2713
701634 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 25618.2 | 0.0492126 | 289 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 543.636 | 0.0416667 | 2714
701648 | Level 1 | Piping System: Domestic Hot Water 1 | -355.33 | Domestic Hot Water 1 | Domestic Hot Water | 138085 | 0.0492126 | 599 | -350 | 0 | -350 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 2930.26 | 0.0416667 | 2715
701653 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 219610 | 0.0492126 | 289 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 4660.27 | 0.0416667 | 2716
701655 | Level 1 | Piping System: Domestic Hot Water 1 | -355.33 | Domestic Hot Water 1 | Domestic Hot Water | 27593 | 0.0492126 | 600 | -350 | 0 | -350 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 585.542 | 0.0416667 | 2717
701676 | Level 1 | Piping System: Domestic Hot Water 1 | -355.33 | Domestic Hot Water 1 | Domestic Hot Water | 36391.9 | 0.0492126 | 290 | -350 | 0 | -350 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 772.26 | 0.0416667 | 2718
701699 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 29255.9 | 0.0492126 | 259 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 620.829 | 0.0416667 | 2719
701714 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 127595 | 0.0492126 | 134 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 2707.66 | 0.0416667 | 2720
701719 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 460740 | 0.104987 | 253 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 4583.06 | 0.104167 | 2721
701723 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 40358.1 | 0.0492126 | 134 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 856.425 | 0.0416667 | 2722
701786 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 5337.1 | 0.0492126 | 134 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 113.257 | 0.0416667 | 2723
701793 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 134 | -285.713 |  | 185.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 2724
701797 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 2687.36 | 0.0492126 | 134 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 57.0275 | 0.0416667 | 2725
701805 | Level 1 | Piping System: Domestic Hot Water 1 | 214.289 | Domestic Hot Water 1 | Domestic Hot Water | 27517.2 | 0.0492126 | 134 | 214.29 | 5212.45 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 583.934 | 0.0416667 | 2726
701829 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 35539.6 | 0.0492126 | 136 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 754.174 | 0.0416667 | 2727
701849 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 15579.2 | 0.0492126 | 268 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 330.601 | 0.0416667 | 2728
701854 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 727.604 | 0.104987 | 263 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 7.23761 | 0.104167 | 2729
701858 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 4039.11 | 0.0492126 | 268 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 85.7125 | 0.0416667 | 2730
701888 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 268 | -285.713 |  | 185.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 2731
702044 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 11838.9 | 0.0492126 | 266 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 251.23 | 0.0416667 | 2737
702140 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 62611.6 | 0.104987 | 270 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 622.809 | 0.104167 | 2738
702147 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 233950 | 0.104987 | 264 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 2327.14 | 0.104167 | 2739
702148 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 13307.8 | 0.104987 | 270 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 132.375 | 0.104167 | 2740
702213 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 66573.5 | 0.0492126 | 118 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1412.73 | 0.0416667 | 2743
702218 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 521854 | 0.104987 | 269 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 5190.98 | 0.104167 | 2744
702222 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 42949.9 | 0.0492126 | 118 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 911.425 | 0.0416667 | 2745
702233 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 847.909 | 0.0492126 | 118 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 17.9932 | 0.0416667 | 2746
702278 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 26927.8 | 0.0492126 | 118 | -285.713 |  | 285.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 571.425 | 0.0416667 | 2747
702282 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 5812.6 | 0.0492126 | 118 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 123.347 | 0.0416667 | 2748
702290 | Level 1 | Piping System: Domestic Hot Water 1 | 314.289 | Domestic Hot Water 1 | Domestic Hot Water | 22804.8 | 0.0492126 | 118 | 314.29 | 4350.73 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 483.933 | 0.0416667 | 2749
702327 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 25875.6 | 0.0492126 | 120 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 549.097 | 0.0416667 | 2750
702364 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 50513.7 | 0.104987 | 311 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 502.469 | 0.104167 | 2751
702369 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 158946 | 0.082021 | 283 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 2023.76 | 0.0833333 | 2752
702390 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 141373 | 0.0656168 | 276 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 2250.02 | 0.0625 | 2753
702413 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 9536.27 | 0.0656168 | 275 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 151.774 | 0.0625 | 2754
702463 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 81060.5 | 0.0492126 | 274 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1720.16 | 0.0416667 | 2755
702476 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 23628.4 | 0.0492126 | 274 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 501.409 | 0.0416667 | 2756
702621 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 9005.81 | 0.0492126 | 142 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 191.109 | 0.0416667 | 2761
702626 | Level 1 | Piping System: Domestic Hot Water 1 | -270.631 | Domestic Hot Water 1 | Domestic Hot Water | 26217.1 | 0.0492126 | 142 | -270.631 |  | 285.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 556.344 | 0.0416667 | 2762
702628 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 16218.4 | 0.0656168 | 282 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 258.124 | 0.0625 | 2763
702634 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 3157.45 | 0.0492126 | 142 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 67.0032 | 0.0416667 | 2764
702644 | Level 1 | Piping System: Domestic Hot Water 1 | 314.289 | Domestic Hot Water 1 | Domestic Hot Water | 22804.8 | 0.0492126 | 142 | 314.29 | 4351.01 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 483.933 | 0.0416667 | 2765
702648 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 163814 | 0.0492126 | 280 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 3476.23 | 0.0416667 | 2766
702655 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 56008.4 | 0.0656168 | 273 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 891.401 | 0.0625 | 2767
702659 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 50186.2 | 0.0492126 | 280 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1064.99 | 0.0416667 | 2768
702679 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 2390.49 | 0.0492126 | 280 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 50.7278 | 0.0416667 | 2769
702722 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 280 | -285.713 |  | 185.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 2770
702763 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 21086.6 | 0.0492126 | 278 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 447.472 | 0.0416667 | 2773
702820 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 134258 | 0.0656168 | 281 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 2136.79 | 0.0625 | 2775
702837 | Level 1 | Piping System: Domestic Hot Water 1 | -355.33 | Domestic Hot Water 1 | Domestic Hot Water | 606022 | 0.0492126 | 301 | -350 | 0 | -350 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 12860.2 | 0.0416667 | 2776
702848 | Level 1 | Piping System: Domestic Hot Water 1 | -330.156 | Domestic Hot Water 1 | Domestic Hot Water | 797.572 | 0.0656168 | 282 | -317.462 |  | -330.156 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 12.6938 | 0.0625 | 2777
702898 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 192894 | 0.0656168 | 293 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 3070.01 | 0.0625 | 2778
702909 | Level 1 | Piping System: Domestic Hot Water 1 | -355.33 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 286 | -350 | 0 | -350 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 2780
702921 | Level 1 | Piping System: Domestic Hot Water 1 | -355.33 | Domestic Hot Water 1 | Domestic Hot Water | 62736.6 | 0.0492126 | 286 | -350 | 0 | -350 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1331.31 | 0.0416667 | 2781
702945 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 7929.77 | 0.0492126 | 587 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 168.275 | 0.0416667 | 2782
702980 | Level 1 | Piping System: Domestic Hot Water 1 | -335.713 | Domestic Hot Water 1 | Domestic Hot Water | 29284 | 0.0492126 | 286 | -335.712 |  | 285.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 621.425 | 0.0416667 | 2783
703082 | Level 1 | Piping System: Domestic Hot Water 1 | -355.33 | Domestic Hot Water 1 | Domestic Hot Water | 32882.4 | 0.0492126 | 274 | -350 | 0 | -350 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 697.785 | 0.0416667 | 2786
703089 | Level 1 | Piping System: Domestic Hot Water 1 | -335.713 | Domestic Hot Water 1 | Domestic Hot Water | 1009.63 | 0.0492126 | 274 | -314.287 |  | -335.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 21.425 | 0.0416667 | 2787
703134 | Level 1 | Piping System: Domestic Hot Water 1 | -335.713 | Domestic Hot Water 1 | Domestic Hot Water | 1009.63 | 0.0492126 | 286 | -314.287 |  | -335.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 21.425 | 0.0416667 | 2788
703186 | Level 1 | Piping System: Domestic Hot Water 1 | -358.105 | Domestic Hot Water 1 | Domestic Hot Water | 27956.1 | 0.0656168 | 239 | -350 | 0 | -350 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 444.936 | 0.0625 | 2789
703193 | Level 1 | Piping System: Domestic Hot Water 1 | -332.538 | Domestic Hot Water 1 | Domestic Hot Water | 947.19 | 0.0656168 | 239 | -317.462 |  | -332.538 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 15.075 | 0.0625 | 2790
703290 | Level 1 | Piping System: Domestic Hot Water 1 | -335.713 | Domestic Hot Water 1 | Domestic Hot Water | 710.393 | 0.0492126 | 290 | -320.638 |  | -335.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 15.075 | 0.0416667 | 2791
703292 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 175156 | 0.0492126 | 288 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 3716.92 | 0.0416667 | 2792
703320 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 52422.9 | 0.0656168 | 285 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 834.337 | 0.0625 | 2793
703370 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 41853.4 | 0.082021 | 295 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 532.893 | 0.0833333 | 2795
703374 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 31376.1 | 0.0492126 | 297 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 665.822 | 0.0416667 | 2796
703453 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 57087.1 | 0.0492126 | 298 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1211.43 | 0.0416667 | 2798
703463 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 16442.4 | 0.0492126 | 298 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 348.919 | 0.0416667 | 2799
703500 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 26927.8 | 0.0492126 | 298 | -285.712 |  | 285.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 571.425 | 0.0416667 | 2800
703632 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 448140 | 0.082021 | 302 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 5705.9 | 0.0833333 | 2805
703651 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 148948 | 0.0492126 | 298 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 3160.77 | 0.0416667 | 2806
703684 | Level 1 | Piping System: Domestic Hot Water 1 | -355.33 | Domestic Hot Water 1 | Domestic Hot Water | 43379.2 | 0.0492126 | 294 | -350 | 0 | -350 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 920.536 | 0.0416667 | 2807
703706 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 13903.9 | 0.0656168 | 306 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 221.287 | 0.0625 | 2808
703713 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 57082.1 | 0.082021 | 272 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 726.792 | 0.0833333 | 2809
703717 | Level 1 | Piping System: Domestic Hot Water 1 | -255.33 | Domestic Hot Water 1 | Domestic Hot Water | 25985.3 | 0.0492126 | 305 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 551.425 | 0.0416667 | 2810
703757 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 1009.63 | 0.0492126 | 305 | -285.713 |  | -264.287 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 21.425 | 0.0416667 | 2811
703762 | Level 1 | Piping System: Domestic Hot Water 1 | -255.33 | Domestic Hot Water 1 | Domestic Hot Water | 58500.8 | 0.0492126 | 305 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1241.43 | 0.0416667 | 2812
703767 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 16418.8 | 0.0492126 | 305 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 348.419 | 0.0416667 | 2813
703844 | Level 1 | Piping System: Domestic Hot Water 1 | -235.713 | Domestic Hot Water 1 | Domestic Hot Water | 24571.6 | 0.0492126 | 305 | -235.713 |  | 285.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 521.425 | 0.0416667 | 2814
703883 | Level 1 | Piping System: Domestic Hot Water 1 | -255.33 | Domestic Hot Water 1 | Domestic Hot Water | 60385.7 | 0.0492126 | 308 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1281.43 | 0.0416667 | 2817
703888 | Level 1 | Piping System: Domestic Hot Water 1 | -270.631 | Domestic Hot Water 1 | Domestic Hot Water | 298.942 | 0.0492126 | 308 | -270.631 |  | -264.287 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 6.34375 | 0.0416667 | 2818
703890 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 197322 | 0.0656168 | 310 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 3140.49 | 0.0625 | 2819
703933 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 15568.7 | 0.0492126 | 308 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 330.377 | 0.0416667 | 2820
703940 | Level 1 | Piping System: Domestic Hot Water 1 | -235.713 | Domestic Hot Water 1 | Domestic Hot Water | 24571.6 | 0.0492126 | 308 | -235.713 |  | 285.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 521.425 | 0.0416667 | 2821
703974 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 27918.7 | 0.0656168 | 304 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 444.34 | 0.0625 | 2824
703996 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 145260 | 0.0492126 | 315 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 3082.51 | 0.0416667 | 2825
704003 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 385476 | 0.104987 | 316 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 3834.4 | 0.104167 | 2826
704007 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 39180 | 0.0492126 | 315 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 831.425 | 0.0416667 | 2827
704075 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 10636.7 | 0.0492126 | 315 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 225.719 | 0.0416667 | 2828
704118 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 31069.9 | 0.0492126 | 313 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 659.324 | 0.0416667 | 2831
704137 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 219040 | 0.0492126 | 113 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 4648.18 | 0.0416667 | 2832
704144 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 17961.5 | 0.104987 | 271 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 178.666 | 0.104167 | 2833
704148 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 395273 | 0.0492126 | 111 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 8387.95 | 0.0416667 | 2834
704153 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 71224.2 | 0.0492126 | 111 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1511.43 | 0.0416667 | 2835
704208 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 59914.5 | 0.0492126 | 111 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1271.43 | 0.0416667 | 2836
704225 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 6537.53 | 0.0492126 | 111 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 138.731 | 0.0416667 | 2837
704251 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 26927.8 | 0.0492126 | 111 | -285.713 |  | 285.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 571.425 | 0.0416667 | 2838
704255 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 2346.54 | 0.0492126 | 111 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 49.7952 | 0.0416667 | 2839
704261 | Level 1 | Piping System: Domestic Hot Water 1 | 314.289 | Domestic Hot Water 1 | Domestic Hot Water | 22804.8 | 0.0492126 | 111 | 314.29 | 4351.01 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 483.933 | 0.0416667 | 2840
704308 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 62132.5 | 0.0492126 | 113 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1318.49 | 0.0416667 | 2841
704350 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 29860.1 | 0.0492126 | 115 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 633.652 | 0.0416667 | 2842
704364 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 199913 | 0.0492126 | 15 | -300 | 0 | -300 | Level: Level 1 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 12252.6 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 4242.29 | 0.0416667 | 2843
704402 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 29544.3 | 0.0492126 | 15 | -285.713 |  | 341.238 | Level: Level 1 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 1810.75 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 626.95 | 0.0416667 | 2845
704421 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 30292.3 | 0.0492126 | 17 | -300 | 0 | -300 | Level: Level 1 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 1856.6 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 642.822 | 0.0416667 | 2846
704464 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 150024 | 0.0492126 | 15 | -300 | 0 | -300 | Level: Level 1 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 9194.9 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 3183.62 | 0.0416667 | 2848
704484 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 45358.8 | 0.0492126 | 12 | -300 | 0 | -300 | Level: Level 1 | 138237 | 2 | 2306.34 | 4196.85 | 20.1772 | 0.0142324 | 7283.31 | 4.5 | 0.0193837 | 0.0349738 | 15 mmø | 962.545 | 0.0416667 | 2849
704492 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 62642.2 | 0.0656168 | 13 | -300 | 0 | -300 | Level: Level 1 | 90907.3 | 2 | 260.535 | 6381.89 | 8.7259 | 0.0130723 | 852.194 | 4.5 | 0.0193837 | 0.0531824 | 20 mmø | 996.981 | 0.0625 | 2850
704522 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 143526 | 0.0492126 | 9 | -300 | 0 | -300 | Level: Level 1 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 8796.61 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 3045.71 | 0.0416667 | 2851
704529 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 380850 | 0.0492126 | 17 | -300 | 0 | -300 | Level: Level 1 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 23342.1 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 8081.89 | 0.0416667 | 2852
704566 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 19839.6 | 0.0492126 | 11 | -300 | 0 | -300 | Level: Level 1 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 1215.96 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 421.01 | 0.0416667 | 2854
704609 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 14025.6 | 0.0492126 | 9 | 200 | 0 | 200 | Level: Level 1 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 859.62 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 297.632 | 0.0416667 | 2855
704620 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 9 | -285.713 |  | 185.713 | Level: Level 1 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 1361.57 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 2856
704647 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 12030.9 | 0.104987 | 336 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 119.673 | 0.104167 | 2857
704898 | Level 1 | Piping System: Domestic Hot Water 1 | -264.245 | Domestic Hot Water 1 | Domestic Hot Water | 126553 | 0.104987 | 328 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 1258.85 | 0.104167 | 2858
704908 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 1904.7 | 0.104987 | 317 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 18.9464 | 0.104167 | 2859
704909 | Level 1 | Piping System: Domestic Hot Water 1 | -303.098 | Domestic Hot Water 1 | Domestic Hot Water | 5125.45 | 0.104987 | 317 | -293.025 | 1 | -256.975 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 50.9838 | 0.104167 | 2860
704911 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 147389 | 0.104987 | 14 | -300 | 0 | -300 | Level: Level 1 | 51723.7 | 2 | 13.9312 | 11216.5 | 2.82482 | 0.0117225 | 67.0098 | 4.5 | 0.0193837 | 0.0934711 | 32 mmø | 1466.1 | 0.104167 | 2861
704917 | Level 1 | Piping System: Domestic Hot Water 1 | -261.28 | Domestic Hot Water 1 | Domestic Hot Water | 90765.5 | 0.082021 | 320 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 1155.66 | 0.0833333 | 2862
704935 | Level 1 | Piping System: Domestic Hot Water 1 | -258.105 | Domestic Hot Water 1 | Domestic Hot Water | 143847 | 0.0656168 | 164 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 2289.39 | 0.0625 | 2863
704946 | Level 1 | Piping System: Domestic Hot Water 1 | -255.33 | Domestic Hot Water 1 | Domestic Hot Water | 104622 | 0.0492126 | 163 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 2220.16 | 0.0416667 | 2864
704960 | Level 1 | Piping System: Domestic Hot Water 1 | -255.33 | Domestic Hot Water 1 | Domestic Hot Water | 100442 | 0.0492126 | 163 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 2131.44 | 0.0416667 | 2865
704976 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 1182.99 | 0.0492126 | 163 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 25.1039 | 0.0416667 | 2866
705036 | Level 1 | Piping System: Domestic Hot Water 1 | -235.713 | Domestic Hot Water 1 | Domestic Hot Water | 19859.2 | 0.0492126 | 163 | -235.713 |  | 185.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 421.425 | 0.0416667 | 2867
705084 | Level 1 | Piping System: Domestic Hot Water 1 | 214.289 | Domestic Hot Water 1 | Domestic Hot Water | 27517.2 | 0.0492126 | 163 | 214.29 | 6926.88 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 583.934 | 0.0416667 | 2868
705085 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 6206.25 | 0.0492126 | 163 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 131.701 | 0.0416667 | 2869
705093 | Level 1 | Piping System: Domestic Hot Water 1 | -255.33 | Domestic Hot Water 1 | Domestic Hot Water | 100673 | 0.0492126 | 155 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 2136.34 | 0.0416667 | 2870
705098 | Level 1 | Piping System: Domestic Hot Water 1 | -258.105 | Domestic Hot Water 1 | Domestic Hot Water | 60057.3 | 0.0656168 | 319 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 955.842 | 0.0625 | 2871
705102 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 3633.23 | 0.0492126 | 155 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 77.0995 | 0.0416667 | 2872
705139 | Level 1 | Piping System: Domestic Hot Water 1 | -235.713 | Domestic Hot Water 1 | Domestic Hot Water | 19859.2 | 0.0492126 | 155 | -235.713 |  | 185.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 421.425 | 0.0416667 | 2873
705143 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 7148 | 0.0492126 | 155 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 151.685 | 0.0416667 | 2874
705149 | Level 1 | Piping System: Domestic Hot Water 1 | 214.289 | Domestic Hot Water 1 | Domestic Hot Water | 27517.2 | 0.0492126 | 155 | 214.29 | 6926.88 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 583.934 | 0.0416667 | 2875
705161 | Level 1 | Piping System: Domestic Hot Water 1 | -255.33 | Domestic Hot Water 1 | Domestic Hot Water | 114586 | 0.0492126 | 322 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 2431.58 | 0.0416667 | 2876
705166 | Level 1 | Piping System: Domestic Hot Water 1 | -261.28 | Domestic Hot Water 1 | Domestic Hot Water | 64912.1 | 0.082021 | 323 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 826.487 | 0.0833333 | 2877
705170 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 42747.2 | 0.0492126 | 322 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 907.124 | 0.0416667 | 2878
705240 | Level 1 | Piping System: Domestic Hot Water 1 | -235.713 | Domestic Hot Water 1 | Domestic Hot Water | 24571.6 | 0.0492126 | 322 | -235.713 |  | 285.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 521.425 | 0.0416667 | 2879
705310 | Level 1 | Piping System: Domestic Hot Water 1 | -255.33 | Domestic Hot Water 1 | Domestic Hot Water | 90497.6 | 0.0492126 | 327 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1920.42 | 0.0416667 | 2885
705315 | Level 1 | Piping System: Domestic Hot Water 1 | -261.28 | Domestic Hot Water 1 | Domestic Hot Water | 148498 | 0.082021 | 318 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 1890.73 | 0.0833333 | 2886
705351 | Level 1 | Piping System: Domestic Hot Water 1 | -255.33 | Domestic Hot Water 1 | Domestic Hot Water | 16576.9 | 0.0492126 | 325 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 351.772 | 0.0416667 | 2888
705369 | Level 1 | Piping System: Domestic Hot Water 1 | -255.33 | Domestic Hot Water 1 | Domestic Hot Water | 45291.1 | 0.0492126 | 330 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 961.106 | 0.0416667 | 2889
705376 | Level 1 | Piping System: Domestic Hot Water 1 | -264.245 | Domestic Hot Water 1 | Domestic Hot Water | 302126 | 0.104987 | 331 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 3005.31 | 0.104167 | 2890
705406 | Level 1 | Piping System: Domestic Hot Water 1 | -255.33 | Domestic Hot Water 1 | Domestic Hot Water | 175622 | 0.0492126 | 333 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 3726.82 | 0.0416667 | 2891
705413 | Level 1 | Piping System: Domestic Hot Water 1 | -264.245 | Domestic Hot Water 1 | Domestic Hot Water | 169595 | 0.104987 | 317 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 1686.99 | 0.104167 | 2892
705417 | Level 1 | Piping System: Domestic Hot Water 1 | -255.33 | Domestic Hot Water 1 | Domestic Hot Water | 40122.5 | 0.0492126 | 333 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 851.425 | 0.0416667 | 2893
705422 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 1611.35 | 0.0492126 | 333 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 34.1938 | 0.0416667 | 2894
705523 | Level 1 | Piping System: Domestic Hot Water 1 | -235.713 | Domestic Hot Water 1 | Domestic Hot Water | 24571.6 | 0.0492126 | 333 | -235.713 |  | 285.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 521.425 | 0.0416667 | 2895
705538 | Level 1 | Piping System: Domestic Hot Water 1 | -255.33 | Domestic Hot Water 1 | Domestic Hot Water | 23624.5 | 0.0492126 | 150 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 501.328 | 0.0416667 | 2898
705545 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 2301.34 | 0.104987 | 153 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 22.8919 | 0.104167 | 2899
705546 | Level 1 | Piping System: Domestic Hot Water 1 | -299.584 | Domestic Hot Water 1 | Domestic Hot Water | 2774.4 | 0.0492126 | 152 | -295.815 | 1 | -254.185 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 58.8745 | 0.0416667 | 2900
705548 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 115629 | 0.104987 | 334 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 1150.19 | 0.104167 | 2901
705554 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 444.757 | 0.0492126 | 150 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 9.43803 | 0.0416667 | 2902
705604 | Level 1 | Piping System: Domestic Hot Water 1 | -235.713 | Domestic Hot Water 1 | Domestic Hot Water | 19859.2 | 0.0492126 | 150 | -235.713 |  | 185.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 421.425 | 0.0416667 | 2903
705608 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 6474.24 | 0.0492126 | 150 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 137.388 | 0.0416667 | 2904
705619 | Level 1 | Piping System: Domestic Hot Water 1 | 214.287 | Domestic Hot Water 1 | Domestic Hot Water | 27517.3 | 0.0492126 | 150 | 214.287 | 7914.47 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 583.936 | 0.0416667 | 2905
705724 | Level 1 | Piping System: Domestic Hot Water 1 | -255.33 | Domestic Hot Water 1 | Domestic Hot Water | 14880.5 | 0.0492126 | 152 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 315.775 | 0.0416667 | 2906
705749 | Level 1 | Piping System: Domestic Hot Water 1 | -264.245 | Domestic Hot Water 1 | Domestic Hot Water | 245768 | 0.104987 | 441 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 2444.7 | 0.104167 | 2907
705755 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 1904.7 | 0.104987 | 337 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 18.9464 | 0.104167 | 2908
705756 | Level 1 | Piping System: Domestic Hot Water 1 | -303.098 | Domestic Hot Water 1 | Domestic Hot Water | 5125.45 | 0.104987 | 337 | -293.025 | 1 | -256.975 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 50.9838 | 0.104167 | 2909
705758 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 146460 | 0.104987 | 335 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 1456.87 | 0.104167 | 2910
705764 | Level 1 | Piping System: Domestic Hot Water 1 | -264.245 | Domestic Hot Water 1 | Domestic Hot Water | 29914.6 | 0.104987 | 441 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 297.566 | 0.104167 | 2911
705785 | Level 2 | Piping System: Domestic Hot Water 1 | 3125.76 | Domestic Hot Water 1 | Domestic Hot Water | 33496.8 | 0.104987 | 441 | -1430 | 0 | -1430 | Level: Level 2 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 333.199 | 0.104167 | 2912
705813 | Level 1 | Piping System: Domestic Hot Water 1 | -226.188 | Domestic Hot Water 1 | Domestic Hot Water | 336012 | 0.104987 | 441 | -226.188 |  | 3116.19 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 3342.38 | 0.104167 | 2913
705942 | Level 1 | Piping System: Domestic Hot Water 1 | -264.245 | Domestic Hot Water 1 | Domestic Hot Water | 30929.6 | 0.104987 | 337 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 307.662 | 0.104167 | 2914
705982 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 23785.1 | 0.082021 | 174 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 302.842 | 0.0833333 | 2915
705989 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 81928.1 | 0.0492126 | 173 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1738.57 | 0.0416667 | 2916
706002 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 329667 | 0.0492126 | 171 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 6995.75 | 0.0416667 | 2917
706013 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 52374.7 | 0.0492126 | 171 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1111.43 | 0.0416667 | 2918
706075 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 2283.75 | 0.0492126 | 171 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 48.4626 | 0.0416667 | 2919
706084 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 26927.8 | 0.0492126 | 171 | -285.713 |  | 285.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 571.425 | 0.0416667 | 2920
706088 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 6322.6 | 0.0492126 | 171 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 134.17 | 0.0416667 | 2921
706096 | Level 1 | Piping System: Domestic Hot Water 1 | 314.287 | Domestic Hot Water 1 | Domestic Hot Water | 22804.9 | 0.0492126 | 171 | 314.287 | 6606.48 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 483.936 | 0.0416667 | 2922
706130 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 21238.1 | 0.0492126 | 173 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 450.686 | 0.0416667 | 2923
706160 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 182258 | 0.082021 | 167 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 2320.59 | 0.0833333 | 2924
706166 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 214084 | 0.082021 | 341 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 2725.8 | 0.0833333 | 2925
706200 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 64302.5 | 0.082021 | 167 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 818.725 | 0.0833333 | 2926
706207 | Level 1 | Piping System: Domestic Hot Water 1 | 188.72 | Domestic Hot Water 1 | Domestic Hot Water | 555.415 | 0.082021 | 167 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 7.07176 | 0.0833333 | 2927
706239 | Level 1 | Piping System: Domestic Hot Water 1 | -279.363 | Domestic Hot Water 1 | Domestic Hot Water | 36028.2 | 0.082021 | 167 | -279.363 |  | 179.363 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 458.725 | 0.0833333 | 2928
706243 | Level 1 | Piping System: Domestic Hot Water 1 | 188.72 | Domestic Hot Water 1 | Domestic Hot Water | 3207.94 | 0.082021 | 167 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 40.8447 | 0.0833333 | 2929
706251 | Level 1 | Piping System: Domestic Hot Water 1 | 214.289 | Domestic Hot Water 1 | Domestic Hot Water | 27517.2 | 0.0492126 | 166 | 214.29 | 5212.45 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 583.934 | 0.0416667 | 2930
706269 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 26349.5 | 0.082021 | 169 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 335.492 | 0.0833333 | 2931
706295 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 129963 | 0.0492126 | 158 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 2757.9 | 0.0416667 | 2932
706302 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 275122 | 0.082021 | 346 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 3502.97 | 0.0833333 | 2933
706306 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 1089.69 | 0.0492126 | 158 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 23.1239 | 0.0416667 | 2934
706406 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 26927.8 | 0.0492126 | 158 | -285.713 |  | 285.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 571.425 | 0.0416667 | 2935
706410 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 12674.4 | 0.0492126 | 158 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 268.96 | 0.0416667 | 2936
706416 | Level 1 | Piping System: Domestic Hot Water 1 | 314.289 | Domestic Hot Water 1 | Domestic Hot Water | 22804.8 | 0.0492126 | 158 | 314.29 | 5782.11 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 483.933 | 0.0416667 | 2937
706508 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 29970.3 | 0.0492126 | 160 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 635.989 | 0.0416667 | 2938
706531 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 285571 | 0.0492126 | 345 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 6060 | 0.0416667 | 2939
706536 | Level 1 | Piping System: Domestic Hot Water 1 | -265.869 | Domestic Hot Water 1 | Domestic Hot Water | 25992.7 | 0.0492126 | 343 | -265.869 |  | 285.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 551.581 | 0.0416667 | 2940
706538 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 14111.7 | 0.082021 | 340 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 179.675 | 0.0833333 | 2941
706566 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 30511 | 0.0492126 | 343 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 647.465 | 0.0416667 | 2942
706610 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 161714 | 0.0492126 | 145 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 3431.67 | 0.0416667 | 2943
706615 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 44303.4 | 0.082021 | 339 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 564.089 | 0.0833333 | 2944
706661 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 29575.9 | 0.0492126 | 147 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 627.621 | 0.0416667 | 2945
706696 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 44128 | 0.0492126 | 145 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 936.425 | 0.0416667 | 2946
706703 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 2328.4 | 0.0492126 | 145 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 49.4101 | 0.0416667 | 2947
706728 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 26927.8 | 0.0492126 | 145 | -285.713 |  | 285.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 571.425 | 0.0416667 | 2948
706732 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 2025.15 | 0.0492126 | 145 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 42.975 | 0.0416667 | 2949
706740 | Level 1 | Piping System: Domestic Hot Water 1 | 314.289 | Domestic Hot Water 1 | Domestic Hot Water | 22804.8 | 0.0492126 | 145 | 314.29 | 4351.01 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 483.933 | 0.0416667 | 2950
706768 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 353885 | 0.0492126 | 98 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 7509.67 | 0.0416667 | 2952
