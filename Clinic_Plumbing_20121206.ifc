Properties of the parts of a building model (IFC2X3), part 8 of 29

# IfcFlowFitting: Elbow - Generic (1654)
Name (M_Elbow - Generic:Elbow - Generic:Elbow - Generic:...) | In | Offset (mm) | Level | Host | Fitting Outside Radius = Insulation Radius | Center Radius | Overall Size = Size | System Classification | Loss Method | System Type | System Name | Angle (deg) | Nominal Radius | Center to End | Fitting Outside Diameter | Tick Size | Nominal Diameter | Mark
1125841 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 45 | 0.0656168 | 0.0366752 | 0.135417 | 0.0224366 | 0.131234 | 15402
1125843 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 45 | 0.0656168 | 0.0366752 | 0.135417 | 0.0224366 | 0.131234 | 15404
1125858 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15406
1125864 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15410
1125866 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15412
1125868 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15414
1125966 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15421
1125972 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15425
1125974 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15427
1125976 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15429
1125989 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15431
1125995 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15435
1125997 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15437
1125999 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15439
1126069 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15442
1126075 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15446
1126077 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15448
1126079 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15450
1126250 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 15455
1126256 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 15459
1126258 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 15461
1126260 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 15463
1126302 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15465
1126308 | Level 1 | -1350 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15469
1126310 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15471
1126312 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15473
1126541 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 45 | 0.0656168 | 0.0366752 | 0.135417 | 0.0224366 | 0.131234 | 15479
1126547 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 45 | 0.0656168 | 0.0366752 | 0.135417 | 0.0224366 | 0.131234 | 15483
1126549 | Level 1 | -1550 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 45 | 0.0656168 | 0.0366752 | 0.135417 | 0.0224366 | 0.131234 | 15485
1126551 | Level 1 | -1550 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 45 | 0.0656168 | 0.0366752 | 0.135417 | 0.0224366 | 0.131234 | 15487
1126566 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15489
1126572 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15493
1126574 | Level 1 | -1550 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15495
1126576 | Level 1 | -1550 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15497
1126659 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15500
1126661 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15502
1126669 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15504
1126670 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15505
1126672 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 15507
1126842 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 15512
1126874 | Level 1 | -1000 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 15515
1126876 | Level 1 | -1000 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 15517
1127140 | Level 1 | 3000 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 15520
1127144 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.0656168 | 0.0366752 | 0.135417 | 0.0224366 | 0.131234 | 15524
1127145 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 15525
1127263 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.109375 | 0.130208 | 65 mmø-65 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 45 | 0.106627 | 0.0539341 | 0.21875 | 0.0362437 | 0.213255 | 15534
1127268 | Level 1 | -1550 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 15538
1127270 | Level 1 | -1550 | Level: Level 2 | Level : Level 2 | 0.109375 | 0.130208 | 65 mmø-65 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 45 | 0.106627 | 0.0539341 | 0.21875 | 0.0362437 | 0.213255 | 15540
1127548 | Level 1 | -1228.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 15552
1127590 | Level 1 | -875.5 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 15558
1127592 | Level 1 | -1228.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 15560
1127594 | Level 1 | -875.5 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 15562
1127873 | Level 1 | 3790.7 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 15567
1127875 | Level 1 | 3790.7 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 15569
1127879 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 15573
1127880 | Level 1 | 3560 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 15574
1127882 | Level 1 | 3560 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 15576
1128235 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15585
1128240 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15586
1128254 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15590
1128255 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15591
1128607 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 15594
1128613 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 15598
1128615 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 15600
1128617 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 15602
1129232 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15611
1129238 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15615
1129240 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15617
1129242 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15619
1129467 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 15621
1129472 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 15622
1129484 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 15624
1129485 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 15625
1151025 | Level 1 | 3970 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 150 mmø-150 mmø | Sanitary | 1 | Piping System: Storm | Storm | 90 | 0.246063 | 0.0677083 | 0.09375 | 0.0375 | 0.492126 | 15720
1151027 | Level 1 | -600 | Level: Level 2 | Level : Level 2 | 0.046875 | 0.0677083 | 150 mmø-150 mmø | Sanitary | 1 | Piping System: Storm | Storm | 45 | 0.246063 | 0.0677083 | 0.09375 | 0.0375 | 0.492126 | 15722
1182449 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 89.9999 | 0.0246063 | 0.0468749 | 0.0520833 | 0.0208333 | 0.0492126 | 15727
1182479 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0035 | 0.0246063 | 0.0468779 | 0.0520833 | 0.0208346 | 0.0492126 | 15732
1182607 | Level 2 | 300 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0042 | 0.0246063 | 0.0468785 | 0.0520833 | 0.0208349 | 0.0492126 | 15736
1182635 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0071 | 0.0246063 | 0.0468808 | 0.0520833 | 0.0208359 | 0.0492126 | 15740
1182674 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0035 | 0.0246063 | 0.0468779 | 0.0520833 | 0.0208346 | 0.0492126 | 15744
1182746 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15747
1182817 | Level 2 | 100 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15751
1182846 | Level 2 | 100 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.003 | 0.0246063 | 0.0468775 | 0.0520833 | 0.0208344 | 0.0492126 | 15755
1182935 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15758
1183041 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15765
1183065 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15768
1183128 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15772
1183154 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0035 | 0.0246063 | 0.0468779 | 0.0520833 | 0.0208346 | 0.0492126 | 15776
1183324 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0008 | 0.0246063 | 0.0468757 | 0.0520833 | 0.0208336 | 0.0492126 | 15782
1183354 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0061 | 0.0246063 | 0.04688 | 0.0520833 | 0.0208355 | 0.0492126 | 15787
1183438 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.001 | 0.0246063 | 0.0468758 | 0.0520833 | 0.0208337 | 0.0492126 | 15792
1183462 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15795
1183534 | Level 2 | 500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15798
1183559 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0035 | 0.0246063 | 0.0468779 | 0.0520833 | 0.0208346 | 0.0492126 | 15801
1183643 | Level 1 | -500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15804
1183668 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0071 | 0.0246063 | 0.0468808 | 0.0520833 | 0.0208359 | 0.0492126 | 15808
1183693 | Level 1 | -500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 89.994 | 0.0246063 | 0.0468701 | 0.0520833 | 0.0208311 | 0.0492126 | 15812
1183721 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0069 | 0.0246063 | 0.0468806 | 0.0520833 | 0.0208358 | 0.0492126 | 15816
1183796 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0035 | 0.0246063 | 0.0468779 | 0.0520833 | 0.0208346 | 0.0492126 | 15820
1183819 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15823
1183972 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15826
1184001 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0035 | 0.0246063 | 0.0468779 | 0.0520833 | 0.0208346 | 0.0492126 | 15830
1184202 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15843
1184226 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 89.9997 | 0.0246063 | 0.0468748 | 0.0520833 | 0.0208332 | 0.0492126 | 15846
1184293 | Level 1 | -1450 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.007 | 0.0246063 | 0.0468807 | 0.0520833 | 0.0208359 | 0.0492126 | 15850
1184325 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15854
1184490 | Level 1 | 711.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15859
1184572 | Level 1 | 711.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0227 | 0.0246063 | 0.0468936 | 0.0520833 | 0.0208416 | 0.0492126 | 15863
1184604 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0019 | 0.0246063 | 0.0468766 | 0.0520833 | 0.020834 | 0.0492126 | 15868
1184627 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15872
1184629 | Level 1 | 711.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15873
1184768 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0042 | 0.0246063 | 0.0468785 | 0.0520833 | 0.0208349 | 0.0492126 | 15880
1184802 | Level 1 | 766.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0542 | 0.0246063 | 0.0469194 | 0.0520833 | 0.0208531 | 0.0492126 | 15884
1184877 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15887
1184902 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0042 | 0.0246063 | 0.0468785 | 0.0520833 | 0.0208349 | 0.0492126 | 15890
1184967 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0042 | 0.0246063 | 0.0468785 | 0.0520833 | 0.0208349 | 0.0492126 | 15893
1184996 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0049 | 0.0246063 | 0.046879 | 0.0520833 | 0.0208351 | 0.0492126 | 15897
1185060 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 89.9994 | 0.0246063 | 0.0468745 | 0.0520833 | 0.0208331 | 0.0492126 | 15901
1185213 | Level 1 | 758.763 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0456 | 0.0246063 | 0.0469123 | 0.0520833 | 0.0208499 | 0.0492126 | 15907
1185302 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15910
1185325 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15913
1185382 | Level 1 | 748.763 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0002 | 0.0246063 | 0.0468751 | 0.0520833 | 0.0208334 | 0.0492126 | 15916
1185441 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0042 | 0.0246063 | 0.0468785 | 0.0520833 | 0.0208349 | 0.0492126 | 15919
1185620 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15924
1185743 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15927
1185799 | Level 1 | 768.584 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0002 | 0.0246063 | 0.0468752 | 0.0520833 | 0.0208334 | 0.0492126 | 15930
1185854 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0042 | 0.0246063 | 0.0468785 | 0.0520833 | 0.0208349 | 0.0492126 | 15933
1185886 | Level 1 | 711.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0227 | 0.0246063 | 0.0468936 | 0.0520833 | 0.0208416 | 0.0492126 | 15937
1185969 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15941
1185997 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0017 | 0.0246063 | 0.0468764 | 0.0520833 | 0.020834 | 0.0492126 | 15946
1186071 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15950
1186095 | TOF Footing | -350 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15954
1186174 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15957
1186200 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 89.9915 | 0.0246063 | 0.0468681 | 0.0520833 | 0.0208303 | 0.0492126 | 15962
1186268 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15967
1186304 | Level 1 | 746.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0002 | 0.0246063 | 0.0468751 | 0.0520833 | 0.0208334 | 0.0492126 | 15970
1186460 | Level 1 | 766.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0003 | 0.0246063 | 0.0468752 | 0.0520833 | 0.0208334 | 0.0492126 | 15973
1186616 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15976
1186638 | Level 1 | 728.763 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0001 | 0.0246063 | 0.0468751 | 0.0520833 | 0.0208334 | 0.0492126 | 15979
1186692 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 89.9977 | 0.0246063 | 0.0468731 | 0.0520833 | 0.0208325 | 0.0492126 | 15983
1187009 | Level 1 | 725.231 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0002 | 0.0246063 | 0.0468751 | 0.0520833 | 0.0208334 | 0.0492126 | 15989
1187164 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 15992
1187204 | Level 1 | 771.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0003 | 0.0246063 | 0.0468752 | 0.0520833 | 0.0208334 | 0.0492126 | 15995
1187245 | Level 1 | 771.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.3964 | 0.0246063 | 0.0472004 | 0.0520833 | 0.020978 | 0.0492126 | 16000
1187300 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16004
1191030 | Level 1 | 500 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0168 | 0.0246063 | 0.0468887 | 0.0520833 | 0.0208394 | 0.0492126 | 16011
1191055 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16014
1191130 | Level 1 | 721.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16017
1191155 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16020
1191251 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0084 | 0.0246063 | 0.0468818 | 0.0520833 | 0.0208364 | 0.0492126 | 16024
1191445 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16036
1191485 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0117 | 0.0246063 | 0.0468846 | 0.0520833 | 0.0208376 | 0.0492126 | 16040
1191669 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16043
1191703 | Level 1 | 751.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.1065 | 0.0246063 | 0.0469622 | 0.0520833 | 0.0208721 | 0.0492126 | 16047
1191766 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16051
1191791 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0084 | 0.0246063 | 0.0468818 | 0.0520833 | 0.0208364 | 0.0492126 | 16054
1191862 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16057
1191886 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0084 | 0.0246063 | 0.0468818 | 0.0520833 | 0.0208364 | 0.0492126 | 16060
1191947 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0084 | 0.0328084 | 0.0573 | 0.0729167 | 0.0291709 | 0.0656168 | 16065
1191978 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0141 | 0.0246063 | 0.0468865 | 0.0520833 | 0.0208385 | 0.0492126 | 16070
1192075 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16075
1192113 | Level 1 | 746.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0963 | 0.0246063 | 0.0469538 | 0.0520833 | 0.0208684 | 0.0492126 | 16080
1192225 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 89.9897 | 0.0246063 | 0.0468666 | 0.0520833 | 0.0208296 | 0.0492126 | 16085
1192252 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16089
1192343 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 89.9902 | 0.0246063 | 0.046867 | 0.0520833 | 0.0208298 | 0.0492126 | 16094
1192380 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16098
1192571 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 89.9899 | 0.0246063 | 0.0468668 | 0.0520833 | 0.0208297 | 0.0492126 | 16102
1192597 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0084 | 0.0246063 | 0.0468818 | 0.0520833 | 0.0208364 | 0.0492126 | 16106
1192656 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16110
1192681 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0084 | 0.0246063 | 0.0468818 | 0.0520833 | 0.0208364 | 0.0492126 | 16114
1192798 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16118
1192830 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16121
1192944 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16124
1192972 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0117 | 0.0246063 | 0.0468846 | 0.0520833 | 0.0208376 | 0.0492126 | 16128
1193066 | Level 1 | 500 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0168 | 0.0246063 | 0.0468887 | 0.0520833 | 0.0208394 | 0.0492126 | 16132
1193094 | Level 1 | 600 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0252 | 0.0246063 | 0.0468957 | 0.0520833 | 0.0208425 | 0.0492126 | 16137
1193230 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.01 | 0.0246063 | 0.0468832 | 0.0520833 | 0.020837 | 0.0492126 | 16141
1193255 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16144
1193328 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.01 | 0.0246063 | 0.0468832 | 0.0520833 | 0.020837 | 0.0492126 | 16147
1193352 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0117 | 0.0246063 | 0.0468846 | 0.0520833 | 0.0208376 | 0.0492126 | 16151
1193419 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16155
1193443 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16158
1193503 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 16161
1193533 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.01 | 0.0328084 | 0.0573017 | 0.0729167 | 0.0291718 | 0.0656168 | 16166
1193637 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.01 | 0.0328084 | 0.0573017 | 0.0729167 | 0.0291718 | 0.0656168 | 16170
1193664 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0084 | 0.0328084 | 0.0573 | 0.0729167 | 0.0291709 | 0.0656168 | 16174
1193733 | Level 1 | 716.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.061 | 0.0246063 | 0.046925 | 0.0520833 | 0.0208555 | 0.0492126 | 16179
1193759 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0084 | 0.0246063 | 0.0468818 | 0.0520833 | 0.0208364 | 0.0492126 | 16183
1193826 | Level 1 | 676.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 89.9503 | 0.0246063 | 0.0468344 | 0.0520833 | 0.0208153 | 0.0492126 | 16188
1193849 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0084 | 0.0246063 | 0.0468818 | 0.0520833 | 0.0208364 | 0.0492126 | 16191
1193905 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.01 | 0.0246063 | 0.0468832 | 0.0520833 | 0.020837 | 0.0492126 | 16195
1193929 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16199
1193991 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.01 | 0.0246063 | 0.0468832 | 0.0520833 | 0.020837 | 0.0492126 | 16203
1194015 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16207
1194088 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0117 | 0.0246063 | 0.0468846 | 0.0520833 | 0.0208376 | 0.0492126 | 16211
1194112 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16214
1194166 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0084 | 0.0246063 | 0.0468818 | 0.0520833 | 0.0208364 | 0.0492126 | 16217
1194190 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0117 | 0.0246063 | 0.0468846 | 0.0520833 | 0.0208376 | 0.0492126 | 16220
1194251 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16223
1194275 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.01 | 0.0246063 | 0.0468832 | 0.0520833 | 0.020837 | 0.0492126 | 16226
1194363 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0117 | 0.0246063 | 0.0468846 | 0.0520833 | 0.0208376 | 0.0492126 | 16229
1194391 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0084 | 0.0246063 | 0.0468818 | 0.0520833 | 0.0208364 | 0.0492126 | 16232
1194446 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.0084 | 0.0246063 | 0.0468818 | 0.0520833 | 0.0208364 | 0.0492126 | 16235
1194480 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0117 | 0.0246063 | 0.0468846 | 0.0520833 | 0.0208376 | 0.0492126 | 16239
1194538 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0142 | 0.0246063 | 0.0468866 | 0.0520833 | 0.0208385 | 0.0492126 | 16244
1194561 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16247
1194627 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.01 | 0.0246063 | 0.0468832 | 0.0520833 | 0.020837 | 0.0492126 | 16251
1194651 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.0084 | 0.0246063 | 0.0468818 | 0.0520833 | 0.0208364 | 0.0492126 | 16255
1194797 | Level 2 | 300 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16259
1194847 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16264
1194931 | Level 2 | 300 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16269
1194961 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16273
1195128 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16279
1195155 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16283
1195533 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.2738 | 0.0246063 | 0.0470996 | 0.0520833 | 0.0209331 | 0.0492126 | 16313
1195593 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.2738 | 0.0246063 | 0.0470995 | 0.0520833 | 0.0209331 | 0.0492126 | 16319
1195711 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 89.998 | 0.0246063 | 0.0468734 | 0.0520833 | 0.0208326 | 0.0492126 | 16323
1195917 | Level 2 | 200.002 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.3035 | 0.0246063 | 0.047124 | 0.0520833 | 0.020944 | 0.0492126 | 16342
1196176 | Level 2 | 500.005 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.5512 | 0.0246063 | 0.0473281 | 0.0520833 | 0.0210347 | 0.0492126 | 16355
1196221 | Level 2 | 200.001 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.2709 | 0.0246063 | 0.0470971 | 0.0520833 | 0.0209321 | 0.0492126 | 16358
1196311 | Level 2 | 199.994 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90.2709 | 0.0246063 | 0.0470971 | 0.0520833 | 0.0209321 | 0.0492126 | 16362
1196755 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90.2709 | 0.0246063 | 0.0470971 | 0.0520833 | 0.0209321 | 0.0492126 | 16371
1196790 | Level 2 | 300 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 16375
1196923 | Level 2 | 300 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 16380
1197050 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16384
1197093 | Level 2 | 500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16388
1200643 | Level 2 | 300 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16394
1201201 | Level 2 | 616.57 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16404
1203513 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Hot Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16434
1203554 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 16437
