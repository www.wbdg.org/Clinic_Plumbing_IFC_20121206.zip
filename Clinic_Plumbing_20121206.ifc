Properties of the parts of a building model (IFC2X3), part 28 of 29

# IfcFlowSegment: Pipe Types:Waste:577155 (822)
Name (Pipe Types:Waste:...) | In | Invert Elevation (mm) | Diameter | Section | Area (mm2) | Overall Size = Size | Reference Level | Slope | Offset (mm) = Start Offset (mm) | End Offset (mm) | Outer Diameter | Inner Diameter | Length (mm) | Mark | Fixture Units | Relative Roughness
646047 | Level 1 | -551.13 | 0.328084 | 76 | 48214.3 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 153.471 | 936 | 4 | 40260
646096 | Level 1 | -551.13 | 0.328084 | 73 | 246308 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 784.024 | 941 | 4 | 40260
646200 | Level 1 | -527.374 | 0.164042 | 502 | 15850.8 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 100.909 | 951 | 0 | 20670
646270 | Level 1 | -527.374 | 0.164042 | 357 | 18120.9 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 115.361 | 955 | 0 | 20670
646358 | Level 1 | -527.415 | 0.164042 | 509 | 496974 | 50 mmø | Level: Level 1 | 0.0000129524 | -501.164 | -501.123 | 0.197917 | 0.17225 | 3163.84 | 957 | 0 | 20670
646377 | Level 1 | -527.374 | 0.164042 | 512 | 13048.6 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 83.0698 | 958 | 0 | 20670
646385 | Level 1 | -527.374 | 0.164042 | 511 | 60106.7 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 382.651 | 959 | 0 | 20670
646430 | Level 1 | -527.374 | 0.164042 | 51 | 7837.35 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 49.8941 | 965 | 1 | 20670
646718 | Level 1 | -526.251 | 0.164042 | 522 | 11465.5 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 72.9919 | 976 | 0 | 20670
646725 | Level 1 | -552.254 | 0.328084 | 349 | 1295112 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 4122.47 | 977 | 0 | 40260
646730 | Level 1 | -526.251 | 0.164042 | 523 | 10878.6 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 69.2556 | 978 | 0 | 20670
646748 | Level 1 | 473.749 | 0.164042 | 134 | 27207.9 | 50 mmø | Level: Level 1 | 0 | 500 | 500 | 0.197917 | 0.17225 | 173.211 | 979 | 2 | 20670
646759 | Level 1 | -526.251 | 0.164042 | 522 | 723524 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 4606.1 | 982 | 0 | 20670
646809 | Level 1 | -26.2509 | 0.164042 | 131 | 26709.2 | 50 mmø | Level: Level 1 | 0 | 0 | 0 | 0.197917 | 0.17225 | 170.036 | 983 | 2 | 20670
646814 | Level 1 | 39.6875 | 0.164042 | 134 | 67069.1 | 50 mmø | Level: Level 1 |  | 39.6875 | 466.663 | 0.197917 | 0.17225 | 426.975 | 984 | 2 | 20670
646856 | Level 1 | 23.8125 | 0.104987 | 130 | 37818.5 | 32 mmø | Level: Level 1 |  | 23.8125 | 400 | 0.138333 | 0.115 | 376.188 | 985 | 2 | 13800
646860 | Level 1 | -460.313 | 0.164042 | 132 | 66071.6 | 50 mmø | Level: Level 1 |  | -460.312 | -39.6875 | 0.197917 | 0.17225 | 420.625 | 986 | 4 | 20670
647030 | Level 1 | -526.251 | 0.164042 | 527 | 20973.7 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 133.523 | 992 | 0 | 20670
647037 | Level 1 | -552.254 | 0.328084 | 525 | 1995559 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 6352.06 | 993 | 0 | 40260
647041 | Level 1 | -526.251 | 0.164042 | 527 | 124541 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 792.854 | 994 | 0 | 20670
647174 | Level 1 | -466.663 | 0.164042 | 527 | 538183 | 50 mmø | Level: Level 1 |  | 2959.52 | -466.663 | 0.197917 | 0.17225 | 3426.18 | 998 | 0 | 20670
647473 | Level 1 | -551.13 | 0.328084 | 532 | 1588667 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 5056.88 | 1014 | 0 | 40260
647520 | Level 1 | -551.13 | 0.328084 | 390 | 835587 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 2659.76 | 1017 | 0 | 40260
647574 | Level 1 | 181.802 | 0.328084 | 84 | 6969.67 | 100 mmø | Level: Level 1 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 22.1851 | 1019 | 4 | 40260
647707 | Level 1 | 53.1812 | 0.104987 | 85 | 66332.2 | 32 mmø | Level: Level 1 |  | 713 | 53.1813 | 0.138333 | 0.115 | 659.819 | 1023 | 1 | 13800
648099 | Level 1 | 43.6562 | 0.104987 | 44 | 67289.8 | 32 mmø | Level: Level 1 |  | 713 | 43.6562 | 0.138333 | 0.115 | 669.344 | 1037 | 1 | 13800
648147 | Level 1 | -51.1302 | 0.328084 | 42 | 204361 | 100 mmø | Level: Level 1 | 0 | 0 | 0 | 0.375 | 0.3355 | 650.5 | 1042 | 1 | 40260
648292 | Level 1 | 30.1625 | 0.104987 | 40 | 68646.3 | 32 mmø | Level: Level 1 |  | 713 | 30.1625 | 0.138333 | 0.115 | 682.838 | 1046 | 1 | 13800
648404 | Level 1 | 30.1625 | 0.104987 | 54 | 68646.3 | 32 mmø | Level: Level 1 |  | 713 | 30.1625 | 0.138333 | 0.115 | 682.838 | 1050 | 1 | 13800
653921 | Level 2 | 4217.74 | 0.328084 | 551 | 110667 | 100 mmø | Level: Level 2 |  | -352.263 | 0 | 0.375 | 0.3355 | 352.262 | 1068 | 0 | 40260
653946 | Level 2 | 4107.87 | 0.328084 | 553 | 70359.8 | 100 mmø | Level: Level 2 | 0 | -411 | -411 | 0.375 | 0.3355 | 223.962 | 1069 | 0 | 40260
653953 | Level 2 | 4107.87 | 0.328084 | 551 | 25066.1 | 100 mmø | Level: Level 2 | 0 | -411 | -411 | 0.375 | 0.3355 | 79.7879 | 1070 | 0 | 40260
653965 | Level 2 | 4107.87 | 0.328084 | 553 | 271162 | 100 mmø | Level: Level 2 | 0 | -411 | -411 | 0.375 | 0.3355 | 863.137 | 1071 | 0 | 40260
653975 | Level 2 | 4751.8 | 0.328084 | 91 | 5984.7 | 100 mmø | Level: Level 2 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 19.0499 | 1072 | 4 | 40260
654003 | Level 2 | 4138.55 | 0.131234 | 555 | 45098.3 | 40 mmø | Level: Level 2 | 0 | -411 | -411 | 0.158333 | 0.134167 | 358.881 | 1074 | 0 | 16100
654015 | Level 2 | 4138.55 | 0.131234 | 555 | 80642.3 | 40 mmø | Level: Level 2 | 0 | -411 | -411 | 0.158333 | 0.134167 | 641.731 | 1076 | 0 | 16100
654021 | Level 2 | 4107.87 | 0.328084 | 556 | 10756.1 | 100 mmø | Level: Level 2 | 0 | -411 | -411 | 0.375 | 0.3355 | 34.2376 | 1077 | 0 | 40260
654060 | Level 2 | 4217.74 | 0.328084 | 556 | 163397 | 100 mmø | Level: Level 2 |  | -352.263 | 167.845 | 0.375 | 0.3355 | 520.107 | 1079 | 0 | 40260
654325 | Level 2 | 4107.87 | 0.328084 | 550 | 1284713 | 100 mmø | Level: Level 2 | 0 | -411 | -411 | 0.375 | 0.3355 | 4089.37 | 1086 | 0 | 40260
654448 | Level 1 | -551.13 | 0.328084 | 562 | 234580 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 746.69 | 1087 | 0 | 40260
654459 | Level 1 | -551.13 | 0.328084 | 561 | 1227111 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 3906.02 | 1089 | 0 | 40260
654511 | Level 2 | 4107.87 | 0.328084 | 564 | 84775.6 | 100 mmø | Level: Level 2 | 0 | -411 | -411 | 0.375 | 0.3355 | 269.849 | 1090 | 0 | 40260
654515 | Level 2 | 4107.87 | 0.328084 | 558 | 752047 | 100 mmø | Level: Level 2 | 0 | -411 | -411 | 0.375 | 0.3355 | 2393.84 | 1091 | 0 | 40260
654586 | Level 2 | 4107.87 | 0.328084 | 565 | 40588 | 100 mmø | Level: Level 2 | 0 | -411 | -411 | 0.375 | 0.3355 | 129.196 | 1092 | 0 | 40260
654593 | Level 2 | 4107.87 | 0.328084 | 563 | 5404.09 | 100 mmø | Level: Level 2 | 0 | -411 | -411 | 0.375 | 0.3355 | 17.2018 | 1093 | 0 | 40260
654595 | Level 2 | 4107.87 | 0.328084 | 565 | 67902 | 100 mmø | Level: Level 2 | 0 | -411 | -411 | 0.375 | 0.3355 | 216.139 | 1094 | 0 | 40260
655125 | Level 1 | -51.1302 | 0.328084 | 567 | 145188 | 100 mmø | Level: Level 1 | 0 | 0 | 0 | 0.375 | 0.3355 | 462.146 | 1108 | 0 | 40260
655169 | Level 1 | 58.7375 | 0.328084 | 568 | 1269683 | 100 mmø | Level: Level 1 |  | 58.7375 | 4100.26 | 0.375 | 0.3355 | 4041.53 | 1110 | 0 | 40260
655202 | Level 2 | 4107.87 | 0.328084 | 568 | 127056 | 100 mmø | Level: Level 2 | 0 | -411 | -411 | 0.375 | 0.3355 | 404.433 | 1111 | 0 | 40260
655210 | Level 2 | 4107.87 | 0.328084 | 569 | 127462 | 100 mmø | Level: Level 2 | 0 | -411 | -411 | 0.375 | 0.3355 | 405.725 | 1112 | 0 | 40260
655242 | Level 2 | 4107.87 | 0.328084 | 568 | 460811 | 100 mmø | Level: Level 2 | 0 | -411 | -411 | 0.375 | 0.3355 | 1466.81 | 1113 | 0 | 40260
655298 | Level 2 | 4107.87 | 0.328084 | 580 | 30055.7 | 100 mmø | Level: Level 2 | 0 | -411 | -411 | 0.375 | 0.3355 | 95.6701 | 1114 | 0 | 40260
655305 | Level 2 | 4107.87 | 0.328084 | 580 | 25571 | 100 mmø | Level: Level 2 | 0 | -411 | -411 | 0.375 | 0.3355 | 81.3952 | 1115 | 0 | 40260
655333 | Level 2 | 4107.87 | 0.328084 | 580 | 1529.83 | 100 mmø | Level: Level 2 | 0 | -411 | -411 | 0.375 | 0.3355 | 4.86959 | 1116 | 0 | 40260
655343 | Level 2 | 4751.8 | 0.328084 | 112 | 7979.61 | 100 mmø | Level: Level 2 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 25.3999 | 1117 | 4 | 40260
655344 | Level 2 | 4217.74 | 0.328084 | 580 | 27386.8 | 100 mmø | Level: Level 2 |  | -265.088 | -352.263 | 0.375 | 0.3355 | 87.175 | 1118 | 0 | 40260
655371 | Level 2 | 4107.87 | 0.328084 | 570 | 23772.5 | 100 mmø | Level: Level 2 | 0 | -411 | -411 | 0.375 | 0.3355 | 75.6701 | 1119 | 0 | 40260
655378 | Level 2 | 4107.87 | 0.328084 | 571 | 44484.8 | 100 mmø | Level: Level 2 | 0 | -411 | -411 | 0.375 | 0.3355 | 141.6 | 1120 | 0 | 40260
655396 | Level 2 | 4107.87 | 0.328084 | 111 | 3046.64 | 100 mmø | Level: Level 2 | 0 | -411 | -411 | 0.375 | 0.3355 | 9.69777 | 1121 | 4 | 40260
655423 | Level 2 | 4751.8 | 0.328084 | 111 | 7979.61 | 100 mmø | Level: Level 2 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 25.3999 | 1122 | 4 | 40260
655424 | Level 2 | 4217.74 | 0.328084 | 111 | 165391 | 100 mmø | Level: Level 2 |  | 174.195 | -352.263 | 0.375 | 0.3355 | 526.457 | 1123 | 4 | 40260
655430 | Level 2 | 4107.87 | 0.328084 | 582 | 61866.5 | 100 mmø | Level: Level 2 | 0 | -411 | -411 | 0.375 | 0.3355 | 196.927 | 1124 | 0 | 40260
655495 | Level 2 | 4107.87 | 0.328084 | 570 | 10397.3 | 100 mmø | Level: Level 2 | 0 | -411 | -411 | 0.375 | 0.3355 | 33.0955 | 1127 | 0 | 40260
655527 | Level 2 | 4435.09 | 0.328084 | 112 | 97109 | 100 mmø | Level: Level 2 |  | 174.195 | -134.913 | 0.375 | 0.3355 | 309.107 | 1132 | 4 | 40260
655600 | Level 2 | 4107.87 | 0.328084 | 572 | 6479.53 | 100 mmø | Level: Level 2 | 0 | -411 | -411 | 0.375 | 0.3355 | 20.625 | 1135 | 0 | 40260
655689 | Level 1 | -551.13 | 0.328084 | 588 | 100881 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 321.113 | 1139 | 0 | 40260
655764 | Level 2 | 2830.67 | 0.328084 | 590 | 544197 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 1732.23 | 1140 | 0 | 40260
655771 | Level 1 | -434.913 | 0.328084 | 590 | 1023523 | 100 mmø | Level: Level 1 |  | -434.912 | 2823.06 | 0.375 | 0.3355 | 3257.98 | 1141 | 0 | 40260
655779 | Level 2 | 2830.67 | 0.328084 | 590 | 360365 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 1147.08 | 1143 | 0 | 40260
655786 | Level 2 | 4751.8 | 0.328084 | 93 | 5380.43 | 100 mmø | Level: Level 2 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 17.1264 | 1144 | 4 | 40260
655787 | Level 2 | 2940.54 | 0.328084 | 590 | 51639.9 | 100 mmø | Level: Level 2 |  | -1465.09 | -1629.46 | 0.375 | 0.3355 | 164.375 | 1145 | 0 | 40260
655905 | Level 2 | 3118.87 | 0.328084 | 592 | 60002.5 | 100 mmø | Level: Level 2 | 0 | -1400 | -1400 | 0.375 | 0.3355 | 190.994 | 1146 | 0 | 40260
655918 | Level 2 | 3143.75 | 0.164042 | 593 | 126149 | 50 mmø | Level: Level 2 | 0 | -1400 | -1400 | 0.197917 | 0.17225 | 803.089 | 1148 | 0 | 20670
655934 | Level 2 | 3143.75 | 0.164042 | 593 | 26253.5 | 50 mmø | Level: Level 2 | 0 | -1400 | -1400 | 0.197917 | 0.17225 | 167.135 | 1149 | 0 | 20670
655986 | Level 2 | 3235.09 | 0.328084 | 596 | 472105 | 100 mmø | Level: Level 2 |  | -1334.91 | 167.845 | 0.375 | 0.3355 | 1502.76 | 1152 | 0 | 40260
656220 | Level 1 | -551.13 | 0.328084 | 412 | 53684.7 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 170.884 | 1155 | 0 | 40260
656227 | Level 1 | -538.964 | 0.262467 | 599 | 53005 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 210.9 | 1156 | 0 | 30680
656382 | Level 1 | 382.474 | 0.104987 | 162 | 21913.6 | 32 mmø | Level: Level 1 | 0 | 400 | 400 | 0.138333 | 0.115 | 217.979 | 1159 | 2 | 13800
656389 | Level 1 | 423.812 | 0.104987 | 162 | 17712.3 | 32 mmø | Level: Level 1 |  | 423.812 | 600 | 0.138333 | 0.115 | 176.188 | 1160 | 2 | 13800
656393 | Level 1 | -453.963 | 0.262467 | 599 | 201458 | 80 mmø | Level: Level 1 |  | -453.963 | 347.612 | 0.291667 | 0.255667 | 801.575 | 1161 | 0 | 30680
656440 | Level 1 | 82.474 | 0.104987 | 165 | 7920.99 | 32 mmø | Level: Level 1 | 0 | 100 | 100 | 0.138333 | 0.115 | 78.7915 | 1162 | 2 | 13800
656447 | Level 1 | -427.769 | 0.104987 | 165 | 50663.2 | 32 mmø | Level: Level 1 |  | -427.769 | 76.1875 | 0.138333 | 0.115 | 503.956 | 1163 | 2 | 13800
656449 | Level 1 | -538.964 | 0.262467 | 597 | 972441 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 3869.22 | 1164 | 0 | 30680
656455 | Level 1 | 82.474 | 0.104987 | 165 | 52646.4 | 32 mmø | Level: Level 1 | 0 | 100 | 100 | 0.138333 | 0.115 | 523.683 | 1165 | 2 | 13800
656516 | Level 1 | 2882.47 | 0.104987 | 600 | 134697 | 32 mmø | Level: Level 1 | 0 | 2900 | 2900 | 0.138333 | 0.115 | 1339.86 | 1168 | 0 | 13800
656524 | Level 1 | 2882.47 | 0.104987 | 600 | 110090 | 32 mmø | Level: Level 1 | 0 | 2900 | 2900 | 0.138333 | 0.115 | 1095.09 | 1169 | 0 | 13800
656946 | Level 1 | -441.263 | 0.328084 | 252 | 118179 | 100 mmø | Level: Level 1 |  | -441.263 | -65.0875 | 0.375 | 0.3355 | 376.175 | 1180 | 0 | 40260
656954 | Level 2 | 2848.84 | 0.262467 | 116 | 96903.2 | 80 mmø | Level: Level 2 | 0 | -1682.2 | -1682.2 | 0.291667 | 0.255667 | 385.565 | 1181 | 2 | 30680
656961 | Level 2 | 2921.14 | 0.164042 | 115 | 259003 | 50 mmø | Level: Level 2 |  | 0 | -1648.86 | 0.197917 | 0.17225 | 1648.86 | 1182 | 2 | 20670
656973 | Level 2 | 2848.84 | 0.262467 | 606 | 21926.5 | 80 mmø | Level: Level 2 | 0 | -1682.2 | -1682.2 | 0.291667 | 0.255667 | 87.2428 | 1185 | 0 | 30680
656979 | Level 1 | 65.0875 | 0.328084 | 604 | 864089 | 100 mmø | Level: Level 1 |  | 2815.57 | 65.0875 | 0.375 | 0.3355 | 2750.48 | 1186 | 0 | 40260
657192 | Level 2 | 2848.84 | 0.262467 | 606 | 892762 | 80 mmø | Level: Level 2 | 0 | -1682.2 | -1682.2 | 0.291667 | 0.255667 | 3552.19 | 1191 | 0 | 30680
657308 | Level 2 | 2830.67 | 0.328084 | 803 | 109403 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 348.241 | 1194 | 0 | 40260
657315 | Level 1 | -434.913 | 0.328084 | 803 | 1023523 | 100 mmø | Level: Level 1 |  | 2823.06 | -434.912 | 0.375 | 0.3355 | 3257.98 | 1195 | 0 | 40260
657770 | Level 2 | 2830.67 | 0.328084 | 613 | 1166480 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 3713.02 | 1202 | 0 | 40260
657867 | Level 2 | 2940.54 | 0.328084 | 613 | 493458 | 100 mmø | Level: Level 2 |  | -1629.46 | -58.7375 | 0.375 | 0.3355 | 1570.73 | 1204 | 0 | 40260
657992 | Level 2 | 2830.67 | 0.328084 | 612 | 74813.6 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 238.139 | 1209 | 0 | 40260
658033 | Level 1 | -551.13 | 0.328084 | 327 | 1401497 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 4461.1 | 1211 | 0 | 40260
658057 | Level 2 | 2830.67 | 0.328084 | 636 | 36224.9 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 115.307 | 1212 | 0 | 40260
658063 | Level 2 | 2830.67 | 0.328084 | 620 | 33047.1 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 105.192 | 1213 | 0 | 40260
658090 | Level 2 | 2830.67 | 0.328084 | 630 | 173209 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 551.34 | 1214 | 0 | 40260
658097 | Level 2 | 2830.67 | 0.328084 | 630 | 181249 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 576.933 | 1215 | 0 | 40260
658158 | Level 2 | 2940.54 | 0.328084 | 630 | 493458 | 100 mmø | Level: Level 2 |  | -1629.46 | -58.7375 | 0.375 | 0.3355 | 1570.73 | 1217 | 0 | 40260
658201 | Level 2 | 2830.67 | 0.328084 | 621 | 46871.2 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 149.196 | 1218 | 0 | 40260
658209 | Level 2 | 2830.67 | 0.328084 | 625 | 316449 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 1007.29 | 1220 | 0 | 40260
658214 | Level 2 | 2830.67 | 0.328084 | 622 | 42622 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 135.67 | 1221 | 0 | 40260
658223 | Level 2 | 2830.67 | 0.328084 | 622 | 48119.8 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 153.17 | 1222 | 0 | 40260
658286 | Level 2 | 2940.54 | 0.328084 | 622 | 493458 | 100 mmø | Level: Level 2 |  | -1629.46 | -58.7375 | 0.375 | 0.3355 | 1570.73 | 1224 | 0 | 40260
658325 | Level 2 | 2830.67 | 0.328084 | 625 | 27068.6 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 86.162 | 1227 | 0 | 40260
658380 | Level 2 | 2830.67 | 0.328084 | 626 | 7783.25 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 24.7749 | 1230 | 0 | 40260
658387 | Level 2 | 2830.67 | 0.328084 | 621 | 1316674 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 4191.1 | 1231 | 0 | 40260
658388 | Level 2 | 2830.67 | 0.328084 | 840 | 76798.3 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 244.457 | 1232 | 0 | 40260
658440 | Level 2 | 2940.54 | 0.328084 | 840 | 493458 | 100 mmø | Level: Level 2 |  | -1629.46 | -58.7375 | 0.375 | 0.3355 | 1570.73 | 1234 | 0 | 40260
658475 | Level 2 | 2830.67 | 0.328084 | 629 | 45466.2 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 144.723 | 1237 | 0 | 40260
658541 | Level 2 | 2830.67 | 0.328084 | 630 | 66264.1 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 210.925 | 1240 | 0 | 40260
658576 | Level 2 | 2855.55 | 0.164042 | 903 | 51515.4 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 327.958 | 1243 | 0 | 20670
658583 | Level 2 | 2830.67 | 0.328084 | 618 | 640160 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 2037.69 | 1244 | 0 | 40260
658587 | Level 2 | 2855.55 | 0.164042 | 900 | 396936 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 2526.98 | 1245 | 0 | 20670
658611 | Level 2 | 4743.75 | 0.164042 | 901 | 31254.7 | 50 mmø | Level: Level 2 | 0 | 200 | 200 | 0.197917 | 0.17225 | 198.973 | 1246 | 0 | 20670
658630 | Level 2 | 4743.75 | 0.164042 | 876 | 59678.1 | 50 mmø | Level: Level 2 | 0 | 200 | 200 | 0.197917 | 0.17225 | 379.922 | 1249 | 0 | 20670
658644 | Level 2 | 4793.81 | 0.104987 | 877 | 37818.5 | 32 mmø | Level: Level 2 |  | 223.812 | 600 | 0.138333 | 0.115 | 376.188 | 1252 | 0 | 13800
659059 | Level 2 | 2830.67 | 0.328084 | 637 | 56023.6 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 178.329 | 1265 | 0 | 40260
659066 | Level 2 | 2830.67 | 0.328084 | 639 | 36421.5 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 115.933 | 1266 | 0 | 40260
659068 | Level 2 | 2830.67 | 0.328084 | 637 | 553702 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 1762.49 | 1267 | 0 | 40260
659146 | Level 2 | 2842.84 | 0.262467 | 641 | 29266.3 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 116.447 | 1272 | 0 | 30680
659153 | Level 2 | 2830.67 | 0.328084 | 634 | 562562 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 1790.69 | 1273 | 0 | 40260
659157 | Level 2 | 2842.84 | 0.262467 | 642 | 154591 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 615.099 | 1274 | 0 | 30680
659219 | Level 2 | 4731.04 | 0.262467 | 732 | 73390.9 | 80 mmø | Level: Level 2 | 0 | 200 | 200 | 0.291667 | 0.255667 | 292.013 | 1275 | 0 | 30680
659230 | Level 2 | 4793.81 | 0.104987 | 879 | 37818.5 | 32 mmø | Level: Level 2 |  | 223.812 | 600 | 0.138333 | 0.115 | 376.188 | 1277 | 0 | 13800
659236 | Level 2 | 2855.55 | 0.164042 | 645 | 42495.3 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 270.533 | 1278 | 0 | 20670
659243 | Level 2 | 2842.84 | 0.262467 | 646 | 712513 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 2835 | 1279 | 0 | 30680
659247 | Level 2 | 2855.55 | 0.164042 | 645 | 265306 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 1688.99 | 1280 | 0 | 20670
659254 | Level 2 | 2855.55 | 0.164042 | 645 | 92695.3 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 590.117 | 1281 | 0 | 20670
659542 | Level 2 | 2842.84 | 0.262467 | 641 | 12938.5 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 51.4806 | 1296 | 0 | 30680
659630 | Level 2 | 2855.55 | 0.164042 | 651 | 15743.2 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 100.224 | 1297 | 0 | 20670
659644 | Level 2 | 2855.55 | 0.164042 | 651 | 111819 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 711.864 | 1298 | 0 | 20670
659651 | Level 2 | 4743.75 | 0.164042 | 652 | 32072 | 50 mmø | Level: Level 2 | 0 | 200 | 200 | 0.197917 | 0.17225 | 204.176 | 1299 | 0 | 20670
659704 | Level 2 | 4793.81 | 0.104987 | 881 | 37818.5 | 32 mmø | Level: Level 2 |  | 223.812 | 600 | 0.138333 | 0.115 | 376.188 | 1301 | 0 | 13800
659720 | Level 2 | 2855.55 | 0.164042 | 649 | 15743.2 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 100.224 | 1302 | 0 | 20670
659730 | Level 2 | 2855.55 | 0.164042 | 830 | 29193.8 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 185.854 | 1303 | 0 | 20670
659885 | Level 2 | 3603.34 | 0.164042 | 651 | 177025 | 50 mmø | Level: Level 2 |  | 160.313 | -966.663 | 0.197917 | 0.17225 | 1126.98 | 1307 | 0 | 20670
660097 | Level 2 | 2830.67 | 0.328084 | 657 | 53154.3 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 169.196 | 1313 | 0 | 40260
660104 | Level 2 | 2842.84 | 0.262467 | 655 | 693883 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 2760.87 | 1314 | 0 | 30680
660108 | Level 2 | 2830.67 | 0.328084 | 657 | 194580 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 619.367 | 1315 | 0 | 40260
660272 | Level 2 | 2830.67 | 0.328084 | 659 | 34304.8 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 109.196 | 1318 | 0 | 40260
660279 | Level 2 | 2842.84 | 0.262467 | 661 | 114650 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 456.176 | 1319 | 0 | 30680
660283 | Level 2 | 2830.67 | 0.328084 | 659 | 359656 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 1144.82 | 1320 | 0 | 40260
660351 | Level 2 | 2940.54 | 0.328084 | 659 | 493458 | 100 mmø | Level: Level 2 |  | -1629.46 | -58.7375 | 0.375 | 0.3355 | 1570.73 | 1322 | 0 | 40260
660376 | Level 2 | 2830.67 | 0.328084 | 663 | 34304.8 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 109.196 | 1323 | 0 | 40260
660383 | Level 2 | 2842.84 | 0.262467 | 665 | 58132 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 231.3 | 1324 | 0 | 30680
660387 | Level 2 | 2830.67 | 0.328084 | 663 | 315441 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 1004.08 | 1325 | 0 | 40260
660432 | Level 2 | 2940.54 | 0.328084 | 663 | 493458 | 100 mmø | Level: Level 2 |  | -1629.46 | -58.7375 | 0.375 | 0.3355 | 1570.73 | 1327 | 0 | 40260
660482 | Level 2 | 2940.54 | 0.328084 | 636 | 493458 | 100 mmø | Level: Level 2 |  | -1629.46 | -58.7375 | 0.375 | 0.3355 | 1570.73 | 1329 | 0 | 40260
660541 | Level 2 | 2830.67 | 0.328084 | 666 | 117633 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 374.437 | 1330 | 0 | 40260
660592 | Level 2 | 2940.54 | 0.328084 | 666 | 493458 | 100 mmø | Level: Level 2 |  | -1629.46 | -58.7375 | 0.375 | 0.3355 | 1570.73 | 1332 | 0 | 40260
660642 | Level 2 | 2830.67 | 0.328084 | 667 | 83976.1 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 267.304 | 1333 | 0 | 40260
660649 | Level 2 | 2830.67 | 0.328084 | 669 | 39668.1 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 126.268 | 1334 | 0 | 40260
660696 | Level 2 | 4731.04 | 0.262467 | 689 | 55403.7 | 80 mmø | Level: Level 2 | 0 | 200 | 200 | 0.291667 | 0.255667 | 220.444 | 1336 | 0 | 30680
660709 | Level 2 | 4793.81 | 0.104987 | 850 | 37818.5 | 32 mmø | Level: Level 2 |  | 223.812 | 600 | 0.138333 | 0.115 | 376.188 | 1338 | 0 | 13800
660715 | Level 2 | 2830.67 | 0.328084 | 671 | 83068.3 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 264.415 | 1339 | 0 | 40260
660722 | Level 2 | 2830.67 | 0.328084 | 366 | 237888 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 757.222 | 1340 | 0 | 40260
660748 | Level 2 | 2842.84 | 0.262467 | 672 | 203762 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 810.743 | 1342 | 0 | 30680
660754 | Level 2 | 4731.04 | 0.262467 | 678 | 71084.2 | 80 mmø | Level: Level 2 | 0 | 200 | 200 | 0.291667 | 0.255667 | 282.835 | 1344 | 0 | 30680
660812 | Level 2 | 4731.04 | 0.262467 | 678 | 46205 | 80 mmø | Level: Level 2 | 0 | 200 | 200 | 0.291667 | 0.255667 | 183.844 | 1346 | 0 | 30680
660818 | Level 2 | 4793.81 | 0.104987 | 848 | 37818.5 | 32 mmø | Level: Level 2 |  | 223.812 | 600 | 0.138333 | 0.115 | 376.188 | 1347 | 0 | 13800
660935 | Level 2 | 2855.55 | 0.164042 | 675 | 166342 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 1058.97 | 1348 | 0 | 20670
660942 | Level 2 | 2842.84 | 0.262467 | 682 | 1984841 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 7897.43 | 1349 | 0 | 30680
660981 | Level 2 | 4743.75 | 0.164042 | 676 | 30089.7 | 50 mmø | Level: Level 2 | 0 | 200 | 200 | 0.197917 | 0.17225 | 191.557 | 1352 | 0 | 20670
660985 | Level 2 | 4743.75 | 0.164042 | 676 | 43784.4 | 50 mmø | Level: Level 2 | 0 | 200 | 200 | 0.197917 | 0.17225 | 278.74 | 1353 | 0 | 20670
661050 | Level 2 | 2915.14 | 0.164042 | 675 | 285127 | 50 mmø | Level: Level 2 |  | -1654.86 | 160.312 | 0.197917 | 0.17225 | 1815.17 | 1356 | 0 | 20670
661097 | Level 2 | 2927.84 | 0.262467 | 672 | 449820 | 80 mmø | Level: Level 2 |  | -1642.16 | 147.613 | 0.291667 | 0.255667 | 1789.78 | 1358 | 0 | 30680
661111 | Level 2 | 4822.39 | 0.262467 | 677 | 49065.4 | 80 mmø | Level: Level 2 |  | 252.387 | 447.612 | 0.291667 | 0.255667 | 195.225 | 1360 | 0 | 30680
661148 | Level 2 | 2855.55 | 0.164042 | 686 | 17605.6 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 112.081 | 1363 | 0 | 20670
661155 | Level 2 | 2842.84 | 0.262467 | 683 | 103915 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 413.464 | 1364 | 0 | 30680
661159 | Level 2 | 2855.55 | 0.164042 | 686 | 72777.2 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 463.314 | 1365 | 0 | 20670
661164 | Level 2 | 4743.75 | 0.164042 | 687 | 39828.5 | 50 mmø | Level: Level 2 | 0 | 200 | 200 | 0.197917 | 0.17225 | 253.556 | 1366 | 0 | 20670
661203 | Level 2 | 4793.81 | 0.104987 | 852 | 37818.5 | 32 mmø | Level: Level 2 |  | 223.812 | 600 | 0.138333 | 0.115 | 376.188 | 1368 | 0 | 13800
661269 | Level 2 | 2915.14 | 0.164042 | 686 | 285127 | 50 mmø | Level: Level 2 |  | -1654.86 | 160.313 | 0.197917 | 0.17225 | 1815.18 | 1370 | 0 | 20670
661306 | Level 2 | 2934.19 | 0.262467 | 691 | 448224 | 80 mmø | Level: Level 2 |  | 147.613 | -1635.81 | 0.291667 | 0.255667 | 1783.43 | 1372 | 0 | 30680
661440 | Level 2 | 2842.84 | 0.262467 | 668 | 509828 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 2028.54 | 1379 | 0 | 30680
661473 | Level 2 | 2855.55 | 0.164042 | 692 | 36502.5 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 232.382 | 1380 | 0 | 20670
661483 | Level 2 | 2855.55 | 0.164042 | 692 | 104645 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 666.191 | 1381 | 0 | 20670
661508 | Level 2 | 4743.75 | 0.164042 | 897 | 33272.1 | 50 mmø | Level: Level 2 | 0 | 200 | 200 | 0.197917 | 0.17225 | 211.817 | 1382 | 0 | 20670
661515 | Level 2 | 2842.84 | 0.262467 | 693 | 351541 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 1398.74 | 1384 | 0 | 30680
661589 | Level 2 | 4793.81 | 0.104987 | 854 | 37818.5 | 32 mmø | Level: Level 2 |  | 223.812 | 600 | 0.138333 | 0.115 | 376.188 | 1391 | 0 | 13800
661637 | Level 2 | 2842.84 | 0.262467 | 690 | 833648 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 3316.98 | 1392 | 0 | 30680
661711 | Level 2 | 2922.28 | 0.164042 | 838 | 286000 | 50 mmø | Level: Level 2 |  | 173.012 | -1647.72 | 0.197917 | 0.17225 | 1820.73 | 1395 | 0 | 20670
661804 | Level 2 | 2842.84 | 0.262467 | 696 | 37156.4 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 147.841 | 1402 | 0 | 30680
661833 | Level 2 | 2927.84 | 0.262467 | 696 | 401150 | 80 mmø | Level: Level 2 |  | -1642.16 | -46.0375 | 0.291667 | 0.255667 | 1596.13 | 1404 | 0 | 30680
661858 | Level 2 | 2855.55 | 0.164042 | 698 | 14220.9 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 90.5333 | 1405 | 0 | 20670
661865 | Level 2 | 2842.84 | 0.262467 | 700 | 807541 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 3213.1 | 1406 | 0 | 30680
661869 | Level 2 | 2855.55 | 0.164042 | 698 | 76241.4 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 485.368 | 1407 | 0 | 20670
661874 | Level 2 | 4743.75 | 0.164042 | 710 | 37566 | 50 mmø | Level: Level 2 | 0 | 200 | 200 | 0.197917 | 0.17225 | 239.153 | 1408 | 0 | 20670
661912 | Level 2 | 4793.81 | 0.104987 | 856 | 37818.5 | 32 mmø | Level: Level 2 |  | 223.812 | 600 | 0.138333 | 0.115 | 376.188 | 1410 | 0 | 13800
661943 | Level 2 | 2855.55 | 0.164042 | 712 | 14220.9 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 90.5333 | 1411 | 0 | 20670
661950 | Level 2 | 2842.84 | 0.262467 | 704 | 506792 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 2016.46 | 1412 | 0 | 30680
661954 | Level 2 | 2855.55 | 0.164042 | 712 | 123365 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 785.368 | 1413 | 0 | 20670
661959 | Level 2 | 4743.75 | 0.164042 | 713 | 33052.7 | 50 mmø | Level: Level 2 | 0 | 200 | 200 | 0.197917 | 0.17225 | 210.42 | 1414 | 0 | 20670
662003 | Level 2 | 4793.81 | 0.104987 | 858 | 37818.5 | 32 mmø | Level: Level 2 |  | 223.812 | 600 | 0.138333 | 0.115 | 376.188 | 1416 | 0 | 13800
662042 | Level 2 | 2927.84 | 0.262467 | 704 | 401150 | 80 mmø | Level: Level 2 |  | -1642.16 | -46.0375 | 0.291667 | 0.255667 | 1596.12 | 1418 | 0 | 30680
662065 | Level 2 | 2855.55 | 0.164042 | 720 | 26787.3 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 170.533 | 1419 | 0 | 20670
662072 | Level 2 | 2842.84 | 0.262467 | 717 | 761670 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 3030.59 | 1420 | 0 | 30680
662076 | Level 2 | 2855.55 | 0.164042 | 720 | 114480 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 728.799 | 1421 | 0 | 20670
662081 | Level 2 | 4743.75 | 0.164042 | 721 | 37548.9 | 50 mmø | Level: Level 2 | 0 | 200 | 200 | 0.197917 | 0.17225 | 239.044 | 1422 | 0 | 20670
662112 | Level 2 | 4793.81 | 0.104987 | 860 | 37818.5 | 32 mmø | Level: Level 2 |  | 223.812 | 600 | 0.138333 | 0.115 | 376.188 | 1424 | 0 | 13800
662118 | Level 2 | 2855.55 | 0.164042 | 706 | 29928.9 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 190.533 | 1425 | 0 | 20670
662125 | Level 2 | 2842.84 | 0.262467 | 702 | 803061 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 3195.28 | 1426 | 0 | 30680
662136 | Level 2 | 4743.75 | 0.164042 | 726 | 37713.9 | 50 mmø | Level: Level 2 | 0 | 200 | 200 | 0.197917 | 0.17225 | 240.094 | 1428 | 0 | 20670
662181 | Level 2 | 4793.81 | 0.104987 | 862 | 37818.5 | 32 mmø | Level: Level 2 |  | 223.812 | 600 | 0.138333 | 0.115 | 376.188 | 1430 | 0 | 13800
662187 | Level 2 | 4743.75 | 0.164042 | 724 | 38497.4 | 50 mmø | Level: Level 2 | 0 | 200 | 200 | 0.197917 | 0.17225 | 245.082 | 1431 | 0 | 20670
662196 | Level 2 | 2855.55 | 0.164042 | 722 | 51361.1 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 326.975 | 1433 | 0 | 20670
662200 | Level 2 | 4793.81 | 0.104987 | 864 | 37818.5 | 32 mmø | Level: Level 2 |  | 223.812 | 600 | 0.138333 | 0.115 | 376.188 | 1434 | 0 | 13800
662265 | Level 1 | -526.251 | 0.164042 | 81 | 3333.37 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 21.2209 | 1435 | 1 | 20670
662330 | Level 2 | 2915.14 | 0.164042 | 698 | 285127 | 50 mmø | Level: Level 2 |  | -1654.86 | 160.313 | 0.197917 | 0.17225 | 1815.18 | 1439 | 0 | 20670
662456 | Level 2 | 2915.14 | 0.164042 | 712 | 285127 | 50 mmø | Level: Level 2 |  | -1654.86 | 160.313 | 0.197917 | 0.17225 | 1815.18 | 1447 | 0 | 20670
662513 | Level 2 | 2830.67 | 0.328084 | 715 | 19247.4 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 61.2663 | 1450 | 0 | 40260
662520 | Level 2 | 2842.84 | 0.262467 | 699 | 765496 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 3045.81 | 1451 | 0 | 30680
662558 | Level 1 | -551.13 | 0.328084 | 382 | 264834 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 842.994 | 1452 | 0 | 40260
662597 | Level 2 | 2915.14 | 0.164042 | 720 | 285127 | 50 mmø | Level: Level 2 |  | -1654.86 | 160.313 | 0.197917 | 0.17225 | 1815.18 | 1454 | 0 | 20670
662634 | Level 2 | 2855.55 | 0.164042 | 706 | 48428.8 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 308.307 | 1455 | 0 | 20670
662649 | Level 2 | 4809.69 | 0.164042 | 728 | 35653.1 | 50 mmø | Level: Level 2 |  | 239.688 | 466.663 | 0.197917 | 0.17225 | 226.975 | 1456 | 0 | 20670
662653 | Level 2 | 2921.49 | 0.164042 | 723 | 284130 | 50 mmø | Level: Level 2 |  | -1648.51 | 160.313 | 0.197917 | 0.17225 | 1808.83 | 1457 | 0 | 20670
662672 | Level 2 | 2915.14 | 0.164042 | 722 | 285127 | 50 mmø | Level: Level 2 |  | -1654.86 | 160.313 | 0.197917 | 0.17225 | 1815.18 | 1459 | 0 | 20670
662689 | Level 2 | 4809.69 | 0.164042 | 725 | 34655.7 | 50 mmø | Level: Level 2 |  | 239.688 | 460.312 | 0.197917 | 0.17225 | 220.625 | 1461 | 0 | 20670
663134 | Level 2 | 2927.84 | 0.262467 | 642 | 449820 | 80 mmø | Level: Level 2 |  | -1642.16 | 147.612 | 0.291667 | 0.255667 | 1789.77 | 1472 | 0 | 30680
663814 | Level 2 | 2830.67 | 0.328084 | 733 | 146405 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 466.021 | 1473 | 0 | 40260
663824 | Level 1 | -436.036 | 0.328084 | 733 | 1023876 | 100 mmø | Level: Level 1 |  | -436.036 | 2823.06 | 0.375 | 0.3355 | 3259.1 | 1474 | 0 | 40260
663827 | Level 2 | 2830.67 | 0.328084 | 734 | 135977 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 432.828 | 1475 | 0 | 40260
663897 | Level 2 | 2940.54 | 0.328084 | 734 | 511911 | 100 mmø | Level: Level 2 |  | -1629.46 | 0 | 0.375 | 0.3355 | 1629.46 | 1477 | 0 | 40260
663913 | Level 2 | 2830.67 | 0.328084 | 733 | 141609 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 450.756 | 1478 | 0 | 40260
664031 | Level 2 | 2830.67 | 0.328084 | 756 | 75650.4 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 240.803 | 1479 | 0 | 40260
664038 | Level 2 | 2830.67 | 0.328084 | 736 | 23791.2 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 75.7296 | 1480 | 0 | 40260
664081 | Level 2 | 2940.54 | 0.328084 | 736 | 493458 | 100 mmø | Level: Level 2 |  | -1629.46 | -58.7375 | 0.375 | 0.3355 | 1570.73 | 1482 | 0 | 40260
664132 | Level 2 | 2842.84 | 0.262467 | 741 | 27209.3 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 108.262 | 1483 | 0 | 30680
664147 | Level 2 | 2842.84 | 0.262467 | 741 | 704450 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 2802.92 | 1485 | 0 | 30680
664314 | Level 2 | 2842.84 | 0.262467 | 214 | 6533.52 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 25.996 | 1493 | 2 | 30680
664323 | Level 2 | 2855.55 | 0.164042 | 746 | 178155 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 1134.17 | 1494 | 0 | 20670
664333 | Level 2 | 2830.67 | 0.328084 | 743 | 415446 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 1322.41 | 1495 | 0 | 40260
664337 | Level 2 | 2855.55 | 0.164042 | 746 | 279817 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 1781.37 | 1496 | 0 | 20670
664345 | Level 2 | 4743.75 | 0.164042 | 747 | 25040.1 | 50 mmø | Level: Level 2 | 0 | 200 | 200 | 0.197917 | 0.17225 | 159.41 | 1497 | 0 | 20670
664489 | Level 2 | 2915.14 | 0.164042 | 746 | 285127 | 50 mmø | Level: Level 2 |  | -1654.86 | 160.313 | 0.197917 | 0.17225 | 1815.18 | 1501 | 0 | 20670
664795 | Level 2 | 2830.67 | 0.328084 | 737 | 625398 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 1990.7 | 1514 | 0 | 40260
664893 | Level 2 | 2830.67 | 0.328084 | 753 | 6362.59 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 20.2528 | 1515 | 0 | 40260
664905 | Level 2 | 4751.8 | 0.328084 | 100 | 2843.11 | 100 mmø | Level: Level 2 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 9.04989 | 1517 | 4 | 40260
664912 | Level 2 | 2830.67 | 0.328084 | 752 | 61094.6 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 194.47 | 1519 | 0 | 40260
664960 | Level 2 | 2940.54 | 0.328084 | 753 | 564641 | 100 mmø | Level: Level 2 |  | -1629.46 | 167.845 | 0.375 | 0.3355 | 1797.31 | 1521 | 0 | 40260
665025 | Level 2 | 2830.67 | 0.328084 | 757 | 3221 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 10.2528 | 1526 | 0 | 40260
665035 | Level 2 | 4751.8 | 0.328084 | 99 | 5984.7 | 100 mmø | Level: Level 2 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 19.0499 | 1528 | 4 | 40260
665042 | Level 2 | 2830.67 | 0.328084 | 756 | 48320.2 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 153.808 | 1530 | 0 | 40260
665084 | Level 2 | 2940.54 | 0.328084 | 757 | 564641 | 100 mmø | Level: Level 2 |  | -1629.46 | 167.845 | 0.375 | 0.3355 | 1797.31 | 1532 | 0 | 40260
665137 | Level 2 | 2830.67 | 0.328084 | 735 | 75650.4 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 240.803 | 1534 | 0 | 40260
665173 | Level 2 | 2830.67 | 0.328084 | 766 | 6036.69 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 19.2154 | 1536 | 0 | 40260
665180 | Level 2 | 2915.14 | 0.164042 | 96 | 298813 | 50 mmø | Level: Level 2 |  | 247.438 | -1654.86 | 0.197917 | 0.17225 | 1902.3 | 1537 | 4 | 20670
665213 | Level 2 | 2830.67 | 0.328084 | 761 | 3221 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 10.2528 | 1538 | 0 | 40260
665218 | Level 2 | 2830.67 | 0.328084 | 766 | 79769.8 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 253.915 | 1539 | 0 | 40260
665222 | Level 2 | 4751.8 | 0.328084 | 98 | 5984.7 | 100 mmø | Level: Level 2 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 19.0499 | 1540 | 4 | 40260
665229 | Level 2 | 2830.67 | 0.328084 | 735 | 32886 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 104.679 | 1542 | 0 | 40260
665264 | Level 2 | 2940.54 | 0.328084 | 761 | 564641 | 100 mmø | Level: Level 2 |  | -1629.46 | 167.845 | 0.375 | 0.3355 | 1797.31 | 1544 | 0 | 40260
665297 | Level 2 | 2830.67 | 0.328084 | 97 | 6036.69 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 19.2154 | 1547 | 4 | 40260
665870 | Level 2 | 2855.55 | 0.164042 | 768 | 14690.5 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 93.5228 | 1560 | 0 | 20670
665877 | Level 2 | 2830.67 | 0.328084 | 760 | 582940 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 1855.56 | 1561 | 0 | 40260
665881 | Level 2 | 2855.55 | 0.164042 | 884 | 3794.75 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 24.1582 | 1562 | 0 | 20670
665903 | Level 2 | 2855.55 | 0.164042 | 771 | 28437.3 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 181.038 | 1563 | 0 | 20670
665910 | Level 2 | 2855.55 | 0.164042 | 768 | 361022 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 2298.33 | 1564 | 0 | 20670
665912 | Level 2 | 2855.55 | 0.164042 | 771 | 102550 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 652.854 | 1565 | 0 | 20670
665923 | Level 2 | 4743.75 | 0.164042 | 772 | 72943.8 | 50 mmø | Level: Level 2 | 0 | 200 | 200 | 0.197917 | 0.17225 | 464.375 | 1566 | 0 | 20670
666119 | Level 2 | 2915.14 | 0.164042 | 771 | 285127 | 50 mmø | Level: Level 2 |  | -1654.86 | 160.313 | 0.197917 | 0.17225 | 1815.18 | 1570 | 0 | 20670
666190 | Level 1 | -551.13 | 0.328084 | 779 | 44331.3 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 141.111 | 1573 | 0 | 40260
666197 | Level 1 | -552.254 | 0.328084 | 776 | 1086844 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 3459.53 | 1574 | 0 | 40260
666202 | Level 1 | -551.13 | 0.328084 | 780 | 87964.6 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 280 | 1575 | 0 | 40260
666296 | Level 2 | -434.913 | 0.328084 | 821 | 1063798 | 100 mmø | Level: Level 2 |  | -5004.91 | -1618.74 | 0.375 | 0.3355 | 3386.18 | 1577 | 0 | 40260
666374 | Level 1 | -551.13 | 0.328084 | 779 | 851555 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 2710.58 | 1578 | 0 | 40260
666407 | Level 2 | 2958.87 | 0.328084 | 781 | 93412.4 | 100 mmø | Level: Level 2 | 0 | -1560 | -1560 | 0.375 | 0.3355 | 297.341 | 1579 | 0 | 40260
666461 | Level 2 | 3068.74 | 0.328084 | 781 | 471636 | 100 mmø | Level: Level 2 |  | -1501.26 | 0 | 0.375 | 0.3355 | 1501.26 | 1581 | 0 | 40260
666509 | Level 2 | 2958.87 | 0.328084 | 824 | 65720.7 | 100 mmø | Level: Level 2 | 0 | -1560 | -1560 | 0.375 | 0.3355 | 209.196 | 1582 | 0 | 40260
666518 | Level 2 | 2958.87 | 0.328084 | 782 | 343594 | 100 mmø | Level: Level 2 | 0 | -1560 | -1560 | 0.375 | 0.3355 | 1093.69 | 1583 | 0 | 40260
666519 | Level 2 | 2958.87 | 0.328084 | 784 | 1244285 | 100 mmø | Level: Level 2 | 0 | -1560 | -1560 | 0.375 | 0.3355 | 3960.68 | 1584 | 0 | 40260
666524 | Level 2 | 2958.87 | 0.328084 | 784 | 48777.8 | 100 mmø | Level: Level 2 | 0 | -1560 | -1560 | 0.375 | 0.3355 | 155.265 | 1585 | 0 | 40260
666538 | Level 2 | 4718.87 | 0.328084 | 785 | 38683.2 | 100 mmø | Level: Level 2 | 0 | 200 | 200 | 0.375 | 0.3355 | 123.132 | 1586 | 0 | 40260
666625 | Level 2 | 3068.74 | 0.328084 | 784 | 514020 | 100 mmø | Level: Level 2 |  | -1501.26 | 134.912 | 0.375 | 0.3355 | 1636.17 | 1590 | 0 | 40260
666794 | Level 2 | 2971.04 | 0.262467 | 790 | 37642.4 | 80 mmø | Level: Level 2 | 0 | -1560 | -1560 | 0.291667 | 0.255667 | 149.774 | 1601 | 0 | 30680
666806 | Level 2 | 2958.87 | 0.328084 | 788 | 455303 | 100 mmø | Level: Level 2 | 0 | -1560 | -1560 | 0.375 | 0.3355 | 1449.28 | 1602 | 0 | 40260
666822 | Level 2 | 3030.64 | 0.082021 | 109 | 120901 | 25 mmø | Level: Level 2 |  | 0 | -1539.36 | 0.109583 | 0.0874167 | 1539.36 | 1604 | 2 | 10490
666827 | Level 2 | 2971.04 | 0.262467 | 108 | 326572 | 80 mmø | Level: Level 2 | 0 | -1560 | -1560 | 0.291667 | 0.255667 | 1299.39 | 1605 | 2 | 30680
666837 | Level 2 | 2971.04 | 0.262467 | 790 | 338786 | 80 mmø | Level: Level 2 | 0 | -1560 | -1560 | 0.291667 | 0.255667 | 1347.99 | 1606 | 0 | 30680
666840 | Level 2 | 3030.64 | 0.082021 | 107 | 120901 | 25 mmø | Level: Level 2 |  | 0 | -1539.36 | 0.109583 | 0.0874167 | 1539.36 | 1607 | 2 | 10490
666924 | Level 2 | 2971.04 | 0.262467 | 110 | 94433.9 | 80 mmø | Level: Level 2 | 0 | -1560 | -1560 | 0.291667 | 0.255667 | 375.74 | 1613 | 2 | 30680
666994 | Level 2 | 3082.23 | 0.164042 | 105 | 272566 | 50 mmø | Level: Level 2 |  | 247.438 | -1487.77 | 0.197917 | 0.17225 | 1735.21 | 1614 | 4 | 20670
666997 | Level 2 | 2971.04 | 0.262467 | 791 | 74520.2 | 80 mmø | Level: Level 2 | 0 | -1560 | -1560 | 0.291667 | 0.255667 | 296.506 | 1615 | 0 | 30680
667004 | Level 2 | 2971.04 | 0.262467 | 793 | 20326.1 | 80 mmø | Level: Level 2 | 0 | -1560 | -1560 | 0.291667 | 0.255667 | 80.8752 | 1616 | 0 | 30680
667069 | Level 2 | 2958.87 | 0.328084 | 796 | 55150.1 | 100 mmø | Level: Level 2 | 0 | -1560 | -1560 | 0.375 | 0.3355 | 175.548 | 1620 | 0 | 40260
667078 | Level 2 | 2958.87 | 0.328084 | 795 | 603127 | 100 mmø | Level: Level 2 | 0 | -1560 | -1560 | 0.375 | 0.3355 | 1919.81 | 1621 | 0 | 40260
667079 | Level 2 | 2958.87 | 0.328084 | 796 | 847266 | 100 mmø | Level: Level 2 | 0 | -1560 | -1560 | 0.375 | 0.3355 | 2696.93 | 1622 | 0 | 40260
667197 | Level 2 | 4751.8 | 0.328084 | 104 | 37408.5 | 100 mmø | Level: Level 2 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 119.075 | 1628 | 4 | 40260
667297 | Level 2 | 4751.8 | 0.328084 | 103 | 41076.4 | 100 mmø | Level: Level 2 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 130.75 | 1630 | 4 | 40260
667298 | Level 2 | 3068.74 | 0.328084 | 796 | 524366 | 100 mmø | Level: Level 2 |  | -1501.26 | 167.845 | 0.375 | 0.3355 | 1669.11 | 1631 | 0 | 40260
669556 | Level 2 | 2830.67 | 0.328084 | 804 | 40588 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 129.196 | 1638 | 0 | 40260
669563 | Level 2 | 2830.67 | 0.328084 | 803 | 708101 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 2253.96 | 1639 | 0 | 40260
669565 | Level 2 | 2830.67 | 0.328084 | 804 | 137266 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 436.933 | 1640 | 0 | 40260
669625 | Level 2 | 2940.54 | 0.328084 | 804 | 493458 | 100 mmø | Level: Level 2 |  | -1629.46 | -58.7375 | 0.375 | 0.3355 | 1570.73 | 1642 | 0 | 40260
669899 | Level 1 | -538.964 | 0.262467 | 293 | 149511 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 594.887 | 1644 | 0 | 30680
681227 | Level 1 | 181.802 | 0.328084 | 121 | 7979.64 | 100 mmø | Level: Level 1 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 25.4 | 1767 | 4 | 40260
681230 | Level 1 | -434.913 | 0.328084 | 121 | 191357 | 100 mmø | Level: Level 1 |  | -434.912 | 174.195 | 0.375 | 0.3355 | 609.107 | 1768 | 4 | 40260
681232 | Level 1 | -538.964 | 0.262467 | 806 | 15631 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 62.1938 | 1769 | 0 | 30680
683518 | Level 1 | 181.802 | 0.328084 | 124 | 43790.5 | 100 mmø | Level: Level 1 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 139.389 | 1848 | 4 | 40260
683519 | Level 1 | -434.913 | 0.328084 | 124 | 191357 | 100 mmø | Level: Level 1 |  | 174.195 | -434.912 | 0.375 | 0.3355 | 609.107 | 1849 | 4 | 40260
683529 | Level 1 | -551.13 | 0.328084 | 808 | 85468.8 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 272.056 | 1851 | 0 | 40260
683538 | Level 1 | -476.188 | 0.104987 | 122 | 119550 | 32 mmø | Level: Level 1 |  | 713 | -476.187 | 0.138333 | 0.115 | 1189.19 | 1852 | 1 | 13800
683539 | Level 1 | -517.526 | 0.104987 | 122 | 26221.8 | 32 mmø | Level: Level 1 | 0 | -500 | -500 | 0.138333 | 0.115 | 260.833 | 1853 | 1 | 13800
683543 | Level 1 | -551.13 | 0.328084 | 812 | 146899 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 467.594 | 1854 | 0 | 40260
683551 | Level 1 | -551.13 | 0.328084 | 617 | 243531 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 775.182 | 1855 | 0 | 40260
684322 | Level 1 | 567.151 | 0.104987 | 159 | 3302.37 | 32 mmø | Level: Level 1 |  | 600 | 567.151 | 0.138333 | 0.115 | 32.8493 | 1895 | 2 | 13800
684323 | Level 1 | 525.812 | 0.104987 | 843 | 54320.1 | 32 mmø | Level: Level 1 | 0 | 543.338 | 543.338 | 0.138333 | 0.115 | 540.332 | 1896 | 0 | 13800
687692 | Level 1 | -477.311 | 0.104987 | 55 | 119663 | 32 mmø | Level: Level 1 |  | 713 | -477.311 | 0.138333 | 0.115 | 1190.31 | 2057 | 1 | 13800
687696 | Level 1 | -552.254 | 0.328084 | 813 | 92408.3 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 294.145 | 2058 | 0 | 40260
692294 | Level 2 | 4141.47 | 0.104987 | 818 | 25640 | 32 mmø | Level: Level 2 | 0 | -411 | -411 | 0.138333 | 0.115 | 255.046 | 2292 | 0 | 13800
692402 | Level 2 | 4107.87 | 0.328084 | 814 | 139085 | 100 mmø | Level: Level 2 | 0 | -411 | -411 | 0.375 | 0.3355 | 442.723 | 2296 | 0 | 40260
692403 | Level 2 | 4141.47 | 0.104987 | 817 | 28185.5 | 32 mmø | Level: Level 2 | 0 | -411 | -411 | 0.138333 | 0.115 | 280.366 | 2297 | 0 | 13800
698390 | Level 2 | 2992.47 | 0.104987 | 823 | 48185.5 | 32 mmø | Level: Level 2 | 0 | -1560 | -1560 | 0.138333 | 0.115 | 479.31 | 2556 | 0 | 13800
698394 | Level 2 | 2958.87 | 0.328084 | 799 | 15371.8 | 100 mmø | Level: Level 2 | 0 | -1560 | -1560 | 0.375 | 0.3355 | 48.93 | 2557 | 0 | 40260
698401 | Level 2 | 2958.87 | 0.328084 | 821 | 10767.8 | 100 mmø | Level: Level 2 | 0 | -1560 | -1560 | 0.375 | 0.3355 | 34.275 | 2558 | 0 | 40260
698701 | Level 2 | 2958.87 | 0.328084 | 824 | 78674.3 | 100 mmø | Level: Level 2 | 0 | -1560 | -1560 | 0.375 | 0.3355 | 250.428 | 2573 | 0 | 40260
699408 | Level 2 | 2905.61 | 0.104987 | 829 | 195270 | 32 mmø | Level: Level 2 |  | 278 | -1664.39 | 0.138333 | 0.115 | 1942.39 | 2603 | 0 | 13800
699411 | Level 2 | 2864.27 | 0.104987 | 829 | 15904.6 | 32 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.138333 | 0.115 | 158.206 | 2604 | 0 | 13800
699420 | Level 2 | 2855.55 | 0.164042 | 649 | 29298.9 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 186.523 | 2606 | 0 | 20670
699431 | Level 2 | 2905.61 | 0.104987 | 832 | 210350 | 32 mmø | Level: Level 2 |  | 428 | -1664.39 | 0.138333 | 0.115 | 2092.39 | 2607 | 0 | 13800
699432 | Level 2 | 2864.27 | 0.104987 | 832 | 21692.6 | 32 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.138333 | 0.115 | 215.78 | 2608 | 0 | 13800
699441 | Level 2 | 2855.55 | 0.164042 | 827 | 187372 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 1192.85 | 2610 | 0 | 20670
703590 | Level 1 | -526.251 | 0.164042 | 322 | 10416.1 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 66.3109 | 2804 | 0 | 20670
724028 | Level 1 | -552.254 | 0.328084 | 367 | 1570939 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 5000.45 | 3564 | 0 | 40260
997915 | Level 2 | 2842.84 | 0.262467 | 835 | 840572 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 3344.53 | 3666 | 0 | 30680
997936 | Level 2 | 4743.75 | 0.164042 | 839 | 43756 | 50 mmø | Level: Level 2 | 0 | 200 | 200 | 0.197917 | 0.17225 | 278.56 | 3667 | 0 | 20670
1061781 | Level 2 | 4943.1 | 0.0492126 | 127 | 1496.18 | 15 mmø | Level: Level 2 | 0 | 381 | 381 | 0.07 | 0.0518333 | 31.75 | 5003 | 0 | 6220
1061785 | Level 2 | 4943.1 | 0.0492126 | 127 | 13460.5 | 15 mmø | Level: Level 2 | 0 | 381 | 381 | 0.07 | 0.0518333 | 285.641 | 5004 | 0 | 6220
1061789 | Level 2 | 2973.08 | 0.0492126 | 127 | 92533.9 | 15 mmø | Level: Level 2 |  | -1596.92 | 366.713 | 0.07 | 0.0518333 | 1963.63 | 5005 | 0 | 6220
1061791 | Level 2 | 2830.67 | 0.328084 | 626 | 176652 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 562.301 | 5006 | 0 | 40260
1076216 | Level 1 | 410.319 | 0.131234 | 129 | 34828.5 | 40 mmø | Level: Level 1 |  | 687.475 | 410.319 | 0.158333 | 0.134167 | 277.156 | 5120 | 2 | 16100
1076675 | Level 1 | 526.987 | 0.131234 | 133 | 20167.5 | 40 mmø | Level: Level 1 |  | 687.475 | 526.988 | 0.158333 | 0.134167 | 160.487 | 5127 | 2 | 16100
1077144 | Level 1 | 662.075 | 0.131234 | 139 | 3191.86 | 40 mmø | Level: Level 1 |  | 687.475 | 662.075 | 0.158333 | 0.134167 | 25.4 | 5131 | 2 | 16100
1077145 | Level 1 | 614.641 | 0.131234 | 139 | 958.972 | 40 mmø | Level: Level 1 | 0 | 635.088 | 635.088 | 0.158333 | 0.134167 | 7.63126 | 5132 | 2 | 16100
1077167 | Level 1 | 662.075 | 0.131234 | 135 | 3191.86 | 40 mmø | Level: Level 1 |  | 687.475 | 662.075 | 0.158333 | 0.134167 | 25.4 | 5133 | 2 | 16100
1077168 | Level 1 | 614.641 | 0.131234 | 135 | 958.971 | 40 mmø | Level: Level 1 | 0 | 635.088 | 635.088 | 0.158333 | 0.134167 | 7.63125 | 5134 | 2 | 16100
1077523 | Level 1 | 662.075 | 0.131234 | 60 | 3191.86 | 40 mmø | Level: Level 1 |  | 687.475 | 662.075 | 0.158333 | 0.134167 | 25.4 | 5142 | 2 | 16100
1077524 | Level 1 | 614.641 | 0.131234 | 60 | 2234.71 | 40 mmø | Level: Level 1 | 0 | 635.088 | 635.088 | 0.158333 | 0.134167 | 17.7832 | 5143 | 2 | 16100
1077841 | Level 1 | 576.987 | 0.131234 | 142 | 13884.3 | 40 mmø | Level: Level 1 |  | 687.475 | 576.987 | 0.158333 | 0.134167 | 110.487 | 5149 | 2 | 16100
1077842 | Level 1 | 529.553 | 0.131234 | 142 | 6544.72 | 40 mmø | Level: Level 1 | 0 | 550 | 550 | 0.158333 | 0.134167 | 52.0813 | 5150 | 2 | 16100
1078042 | Level 1 | 662.075 | 0.131234 | 146 | 3191.86 | 40 mmø | Level: Level 1 |  | 687.475 | 662.075 | 0.158333 | 0.134167 | 25.4 | 5155 | 2 | 16100
1078043 | Level 1 | 614.641 | 0.131234 | 146 | 3857.81 | 40 mmø | Level: Level 1 | 0 | 635.088 | 635.088 | 0.158333 | 0.134167 | 30.6995 | 5156 | 2 | 16100
1078229 | Level 1 | 610.319 | 0.131234 | 149 | 9695.74 | 40 mmø | Level: Level 1 |  | 687.475 | 610.319 | 0.158333 | 0.134167 | 77.1562 | 5161 | 2 | 16100
1078455 | Level 1 | 610.319 | 0.131234 | 152 | 9695.74 | 40 mmø | Level: Level 1 |  | 687.475 | 610.319 | 0.158333 | 0.134167 | 77.1562 | 5166 | 2 | 16100
1078760 | Level 1 | 610.319 | 0.131234 | 155 | 9695.74 | 40 mmø | Level: Level 1 |  | 687.475 | 610.319 | 0.158333 | 0.134167 | 77.1562 | 5171 | 2 | 16100
1079109 | Level 1 | 300 | 0.131234 | 841 | 26389.5 | 40 mmø | Level: Level 1 |  | 510.001 | 300 | 0.158333 | 0.134167 | 210.001 | 5177 | 0 | 16100
1079116 | Level 1 | 576.676 | 0.131234 | 160 | 13923.4 | 40 mmø | Level: Level 1 |  | 687.475 | 576.676 | 0.158333 | 0.134167 | 110.799 | 5178 | 2 | 16100
1079259 | Level 1 | 610.319 | 0.131234 | 158 | 9695.74 | 40 mmø | Level: Level 1 |  | 687.475 | 610.319 | 0.158333 | 0.134167 | 77.1562 | 5189 | 2 | 16100
1079490 | Level 1 | 134.131 | 0.131234 | 164 | 69535.2 | 40 mmø | Level: Level 1 |  | 687.475 | 134.131 | 0.158333 | 0.134167 | 553.344 | 5190 | 2 | 16100
1079725 | Level 1 | 610.319 | 0.131234 | 161 | 9695.74 | 40 mmø | Level: Level 1 |  | 687.475 | 610.319 | 0.158333 | 0.134167 | 77.1562 | 5191 | 2 | 16100
1080047 | Level 1 | 662.075 | 0.131234 | 167 | 3191.86 | 40 mmø | Level: Level 1 |  | 687.475 | 662.075 | 0.158333 | 0.134167 | 25.4 | 5204 | 2 | 16100
1080048 | Level 1 | 614.641 | 0.131234 | 167 | 476.159 | 40 mmø | Level: Level 1 | 0 | 635.088 | 635.088 | 0.158333 | 0.134167 | 3.78916 | 5205 | 2 | 16100
1080188 | Level 1 | -538.964 | 0.262467 | 292 | 122154 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 486.035 | 5206 | 0 | 30680
1080330 | Level 1 | -473.013 | 0.131234 | 170 | 145831 | 40 mmø | Level: Level 1 |  | 687.475 | -473.013 | 0.158333 | 0.134167 | 1160.49 | 5207 | 2 | 16100
1080331 | Level 1 | -520.447 | 0.131234 | 170 | 10916.8 | 40 mmø | Level: Level 1 | 0 | -500 | -500 | 0.158333 | 0.134167 | 86.8732 | 5208 | 2 | 16100
1080343 | Level 1 | -526.251 | 0.164042 | 847 | 121949 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 776.351 | 5210 | 0 | 20670
1080541 | Level 1 | 610.319 | 0.131234 | 172 | 9695.74 | 40 mmø | Level: Level 1 |  | 687.475 | 610.319 | 0.158333 | 0.134167 | 77.1562 | 5215 | 2 | 16100
1080831 | Level 1 | -473.013 | 0.131234 | 175 | 145831 | 40 mmø | Level: Level 1 |  | 687.475 | -473.013 | 0.158333 | 0.134167 | 1160.49 | 5220 | 2 | 16100
1080832 | Level 1 | -520.447 | 0.131234 | 175 | 22989 | 40 mmø | Level: Level 1 | 0 | -500 | -500 | 0.158333 | 0.134167 | 182.94 | 5221 | 2 | 16100
1081183 | Level 1 | -473.013 | 0.131234 | 178 | 145831 | 40 mmø | Level: Level 1 |  | 687.475 | -473.013 | 0.158333 | 0.134167 | 1160.49 | 5230 | 2 | 16100
1081184 | Level 1 | -520.447 | 0.131234 | 178 | 31313 | 40 mmø | Level: Level 1 | 0 | -500 | -500 | 0.158333 | 0.134167 | 249.181 | 5231 | 2 | 16100
1083573 | Level 2 | 2830.67 | 0.328084 | 871 | 271927 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 865.57 | 5296 | 0 | 40260
1083583 | Level 1 | -441.263 | 0.328084 | 387 | 1023523 | 100 mmø | Level: Level 1 |  | -441.263 | 2816.71 | 0.375 | 0.3355 | 3257.98 | 5297 | 0 | 40260
1083636 | Level 2 | 2940.54 | 0.328084 | 871 | 511911 | 100 mmø | Level: Level 2 |  | -1629.46 | 0 | 0.375 | 0.3355 | 1629.46 | 5299 | 0 | 40260
1083652 | Level 2 | 2830.67 | 0.328084 | 869 | 29031.3 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 92.4095 | 5300 | 0 | 40260
1083659 | Level 2 | 2830.67 | 0.328084 | 867 | 265938 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 846.506 | 5301 | 0 | 40260
1083660 | Level 2 | 2830.67 | 0.328084 | 869 | 197463 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 628.546 | 5302 | 0 | 40260
1083735 | Level 2 | 2855.55 | 0.164042 | 873 | 7217.03 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 45.945 | 5304 | 0 | 20670
1083746 | Level 2 | 2830.67 | 0.328084 | 868 | 156514 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 498.201 | 5305 | 0 | 40260
1083750 | Level 2 | 2855.55 | 0.164042 | 873 | 646598 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 4116.37 | 5306 | 0 | 20670
1084256 | Level 2 | 3727.84 | 0.164042 | 904 | 157468 | 50 mmø | Level: Level 2 |  | -842.162 | 160.313 | 0.197917 | 0.17225 | 1002.47 | 5313 | 0 | 20670
1085678 | Level 2 | 2861.35 | 0.131234 | 886 | 46598 | 40 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.158333 | 0.134167 | 370.815 | 5343 | 0 | 16100
1085685 | Level 2 | 2855.55 | 0.164042 | 769 | 76908.2 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 489.613 | 5344 | 0 | 20670
1085720 | Level 2 | 2861.35 | 0.131234 | 886 | 9586.32 | 40 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.158333 | 0.134167 | 76.2855 | 5350 | 0 | 16100
1086531 | Level 1 | -520.447 | 0.131234 | 203 | 10170 | 40 mmø | Level: Level 1 | 0 | -500 | -500 | 0.158333 | 0.134167 | 80.9302 | 5369 | 1 | 16100
1086651 | Level 1 | 855.474 | 0.104987 | 201 | 3723.74 | 32 mmø | Level: Level 1 | 0 | 873 | 873 | 0.138333 | 0.115 | 37.0407 | 5373 | 0.5 | 13800
1086658 | Level 1 | 855.474 | 0.104987 | 205 | 6026.88 | 32 mmø | Level: Level 1 | 0 | 873 | 873 | 0.138333 | 0.115 | 59.9505 | 5374 | 0.5 | 13800
1086665 | Level 1 | 855.474 | 0.104987 | 205 | 3723.74 | 32 mmø | Level: Level 1 | 0 | 873 | 873 | 0.138333 | 0.115 | 37.0407 | 5375 | 0.5 | 13800
1086767 | Level 1 | -551.13 | 0.328084 | 222 | 623236 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 1983.82 | 5376 | 0 | 40260
1086772 | Level 1 | -520.447 | 0.131234 | 203 | 6671.89 | 40 mmø | Level: Level 1 | 0 | -500 | -500 | 0.158333 | 0.134167 | 53.0932 | 5377 | 1 | 16100
1086780 | Level 1 | -473.013 | 0.131234 | 203 | 164956 | 40 mmø | Level: Level 1 |  | 839.662 | -473.013 | 0.158333 | 0.134167 | 1312.67 | 5378 | 1 | 16100
1086782 | Level 1 | 855.474 | 0.104987 | 201 | 37026.8 | 32 mmø | Level: Level 1 | 0 | 873 | 873 | 0.138333 | 0.115 | 368.312 | 5379 | 0.5 | 13800
1096318 | Level 1 | -520.447 | 0.131234 | 892 | 295309 | 40 mmø | Level: Level 1 | 0 | -500 | -500 | 0.158333 | 0.134167 | 2349.99 | 5393 | 0 | 16100
1096325 | Level 1 | -487.3 | 0.03125 | 889 | 19417.5 | 10 mmø | Level: Level 1 |  | 161.6 | -487.3 | 0.03125 | 0.03125 | 648.9 | 5394 | 0 | 3750
1096330 | Level 1 | -520.447 | 0.131234 | 892 | 68615.5 | 40 mmø | Level: Level 1 | 0 | -500 | -500 | 0.158333 | 0.134167 | 546.025 | 5395 | 0 | 16100
1096340 | Level 1 | -520.447 | 0.131234 | 892 | 1528466 | 40 mmø | Level: Level 1 | 0 | -500 | -500 | 0.158333 | 0.134167 | 12163.1 | 5396 | 0 | 16100
1096353 | Level 1 | -551.13 | 0.328084 | 890 | 737471 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 2347.44 | 5397 | 0 | 40260
1097979 | Level 1 | -538.964 | 0.262467 | 293 | 23673.6 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 94.1944 | 5398 | 0 | 30680
1097989 | Level 1 | -473.013 | 0.131234 | 893 | 59440.5 | 40 mmø | Level: Level 1 |  | 0 | -473.013 | 0.158333 | 0.134167 | 473.013 | 5399 | 0 | 16100
1098211 | Level 1 | -473.013 | 0.131234 | 207 | 59440.5 | 40 mmø | Level: Level 1 |  | 0 | -473.013 | 0.158333 | 0.134167 | 473.013 | 5405 | 2 | 16100
1098375 | Level 1 | -540.086 | 0.262467 | 895 | 132820 | 80 mmø | Level: Level 1 | 0 | -501.102 | -501.123 | 0.291667 | 0.255667 | 528.475 | 5411 | 0 | 30680
1098399 | Level 1 | -540.064 | 0.262467 | 210 | 47028.5 | 80 mmø | Level: Level 1 | 0 | -501.1 | -501.1 | 0.291667 | 0.255667 | 187.121 | 5412 | 2 | 30680
