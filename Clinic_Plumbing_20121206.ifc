Properties of the parts of a building model (IFC2X3), part 21 of 29

# IfcFlowSegment: Pipe Types:Cold Water:677372 (822)
Name (Pipe Types:Cold Water:...) | In | Friction Factor | Reynolds Number | Flow State | Pressure Drop | Velocity | Flow | Fixture Units | Relative Roughness | Friction | Mark | Area (mm2) | Schedule/Type | Roughness | Material | Pipe Segment | Diameter | Section | Invert Elevation (mm) | System Name | End Offset (mm) | Start Offset (mm) = Offset (mm) | Reference Level | Slope | Outer Diameter | Size = Overall Size | Inner Diameter | Length (mm)
698364 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2554 | 28485.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 778 | 4764.67 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 604.474
698519 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2566 | 26743 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 645 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 425.628
698526 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2567 | 152305 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 642 | 3052.58 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.125 | 40 mmø | 0.114304 | 1212
698546 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2568 | 85770.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 645 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 1365.08
698553 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2569 | 2827.53 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 645 | 4761.9 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 45.0015
698591 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2570 | 104620 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 645 | 3087.46 | Domestic Cold Water 1 | 182.538 | -1482.54 | Level: Level 2 |  | 0.0625 | 20 mmø | 0.0531824 | 1665.08
698752 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2575 | 3013.31 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 779 | 4764.67 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 63.9443
698831 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2576 | 87384.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 646 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 1390.77
698837 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2577 | 7128.69 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 643 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 113.457
698838 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2578 | 14619 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 646 | 4761.9 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 232.668
698873 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2579 | 104620 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 646 | 3087.46 | Domestic Cold Water 1 | 182.538 | -1482.54 | Level: Level 2 |  | 0.0625 | 20 mmø | 0.0531824 | 1665.08
698909 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2583 | 87923.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 650 | 4752.58 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.125 | 40 mmø | 0.114304 | 699.675
698921 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2584 | 203554 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 650 | 3123.18 | Domestic Cold Water 1 | 173.013 | -1446.82 | Level: Level 2 |  | 0.125 | 40 mmø | 0.114304 | 1619.83
698923 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2585 | 344899 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 630 | 3046.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 2195.69
698934 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2586 | 11614.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 651 | 4752.58 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.125 | 40 mmø | 0.114304 | 92.4233
698938 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2587 | 8408.69 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 652 | 4752.58 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.125 | 40 mmø | 0.114304 | 66.9142
698993 | Level 2 | 0.0142324 | 100715 | 2 | 24403.8 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 2594 | 50323 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 75 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1067.89
699003 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 11216.5 | 0 | 2595 | 227841 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.104987 | 655 | 3055.76 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.104167 | 32 mmø | 0.0934711 | 2266.37
699007 | Level 2 | 0.0142324 | 100715 | 2 | 24027.6 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 2596 | 49547.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 75 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1051.43
699012 | Level 2 | 0.0142324 | 100715 | 2 | 1125.56 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 2597 | 2321.02 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 75 | 4764.67 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 49.2536
699036 | Level 2 | 0.0142324 | 100715 | 2 | 38196 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 2598 | 78764 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 75 | 3084.29 | Domestic Cold Water 1 | 185.713 | -1485.71 | Level: Level 2 |  | 0.0416667 | 15 mmø | 0.0349738 | 1671.43
699091 | Level 2 | 0.0142324 | 100715 | 2 | 19971.7 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 2599 | 41183.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 77 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 873.943
699121 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2600 | 26235.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 659 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 417.548
699130 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2601 | 110173 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 541 | 3058.72 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 1402.77
699134 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2602 | 173563 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 659 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 2762.34
699452 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2611 | 36099.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 661 | 4064.67 | Domestic Cold Water 1 | -500 | -500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 766.061
699457 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2612 | 45066.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 661 | 3099.37 | Domestic Cold Water 1 | -514.287 | -1470.63 | Level: Level 2 |  | 0.0416667 | 15 mmø | 0.0349738 | 956.344
699459 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2613 | 127000 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 662 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 2021.27
699509 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2617 | 125168 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 664 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 2656.15
699518 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2618 | 31938.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 665 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 508.321
699572 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2619 | 1005.46 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 664 | 4764.67 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 21.3366
699581 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2620 | 78764 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 664 | 3084.29 | Domestic Cold Water 1 | 185.713 | -1485.71 | Level: Level 2 |  | 0.0416667 | 15 mmø | 0.0349738 | 1671.43
699596 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2623 | 36646.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 667 | 4064.67 | Domestic Cold Water 1 | -500 | -500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 777.665
699603 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2624 | 45066.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 667 | 3099.37 | Domestic Cold Water 1 | -514.287 | -1470.63 | Level: Level 2 |  | 0.0416667 | 15 mmø | 0.0349738 | 956.344
699605 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2625 | 85654.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 669 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 1363.24
699799 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2630 | 46951.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 658 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 747.252
700929 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2679 | 13618.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 675 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 216.745
700936 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 2680 | 528463 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 334 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 2587.93
700940 | Level 1 | 0.0130723 | 154542 | 2 | 9628.75 | 35.1042 | 0.0779803 | 20 | 6381.89 | 4283.94 | 2681 | 43044.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 3 | 191.895 | Domestic Cold Water 1 | 200 | 200 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 685.081
701018 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2682 | 42584.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 675 | -495.216 | Domestic Cold Water 1 | 182.538 | -495.216 | Level: Level 1 |  | 0.0625 | 20 mmø | 0.0531824 | 677.753
701075 | Level 1 | 0.0130723 | 119218 | 2 | 649.787 | 27.0804 | 0.0601563 | 10 | 6381.89 | 2549.38 | 2683 | 4881.25 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 5 | 191.895 | Domestic Cold Water 1 | 200 | 200 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 77.6875
701081 | Level 1 | 0.0130723 | 119218 | 2 | 1067.99 | 27.0804 | 0.0601563 | 10 | 6381.89 | 2549.38 | 2684 | 8022.84 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 2 | 191.895 | Domestic Cold Water 1 | 200 | 200 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 127.688
701092 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2685 | 10167.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 157 | 191.895 | Domestic Cold Water 1 | 200 | 200 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 161.825
701097 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2686 | 27105.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 156 | 223.018 | Domestic Cold Water 1 | 798.223 | 223.019 | Level: Level 1 | 5720 | 0.0416667 | 15 mmø | 0.0349738 | 575.205
701101 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2687 | 4395.78 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 673 | 191.895 | Domestic Cold Water 1 | 200 | 200 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 69.9611
701110 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2688 | 9131.23 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 160 | 191.895 | Domestic Cold Water 1 | 200 | 200 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 145.328
701115 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2689 | 63361.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 675 | 191.895 | Domestic Cold Water 1 | 200 | 200 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 1008.43
701116 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2690 | 342.339 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 160 | 191.895 | Domestic Cold Water 1 | 200 | 200 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 5.4485
701123 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2691 | 1983.57 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 160 | 191.895 | Domestic Cold Water 1 | 200 | 200 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 31.5695
701129 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2692 | 27105.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 159 | 223.02 | Domestic Cold Water 1 | 798.223 | 223.021 | Level: Level 1 | 2994.38 | 0.0416667 | 15 mmø | 0.0349738 | 575.202
701137 | Level 1 | 0.0122545 | 85661.5 | 2 | 38.1433 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 2693 | 1994.91 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 4 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 25.4
701138 | Level 1 | 0.0122545 | 85661.5 | 2 | 185.553 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 2694 | 9704.51 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 4 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 123.562
701141 | Level 1 | 0.0122545 | 85661.5 | 2 | 665.255 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 2695 | 34793.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 4 | 224.606 | Domestic Cold Water 1 | 667.606 | 224.606 | Level: Level 1 |  | 0.0833333 | 25 mmø | 0.0740157 | 443
701153 | Level 1 | 0.0122545 | 85661.5 | 2 | 38.1433 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 2696 | 1994.91 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 1 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 25.4
701154 | Level 1 | 0.0122545 | 85661.5 | 2 | 185.553 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 2697 | 9704.51 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 1 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 123.562
701157 | Level 1 | 0.0122545 | 85661.5 | 2 | 665.255 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 2698 | 34793.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 1 | 224.606 | Domestic Cold Water 1 | 667.606 | 224.606 | Level: Level 1 |  | 0.0833333 | 25 mmø | 0.0740157 | 443
701329 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2700 | 23756.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 672 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 378.099
701898 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2732 | 8353.93 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 680 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 177.276
701906 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 2733 | 785292 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 336 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 3845.64
701910 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2734 | 4981.58 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 680 | 194.67 | Domestic Cold Water 1 | 200 | 200 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 105.713
701945 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2735 | 32237.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 680 | -498.391 | Domestic Cold Water 1 | 185.713 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 684.103
702029 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2736 | 6255.88 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 678 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 132.754
702570 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2758 | 76078.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 682 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1614.44
702613 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2760 | 60688.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 681 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 965.885
704551 | Level 1 | 0.0130723 | 66232.2 | 2 | 7794.2 | 15.0447 | 0.0334201 | 2.25 | 6381.89 | 786.845 | 2853 | 189704 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 63 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 3019.23
705284 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2882 | 93795 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 688 | -255.33 | Domestic Cold Water 1 | -250 | -250 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1990.39
705289 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2883 | 10321.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 686 | -483.309 | Domestic Cold Water 1 | -264.287 | -483.309 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 219.022
705291 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2884 | 48727.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 493 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 775.516
705336 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2887 | 24991.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 686 | -255.33 | Domestic Cold Water 1 | -250 | -250 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 530.333
707426 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2988 | 42059.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 101 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 892.531
707433 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2989 | 149310 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 398 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 950.54
707437 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2990 | 42323 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 101 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 898.123
707442 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2991 | 1628.78 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 101 | 194.67 | Domestic Cold Water 1 | 200 | 200 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 34.5638
707484 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2992 | 32237.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 101 | -498.391 | Domestic Cold Water 1 | 185.713 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 684.103
707488 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2993 | 3035.96 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 101 | 194.67 | Domestic Cold Water 1 | 200 | 200 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 64.425
707498 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2994 | 27517.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 101 | 214.287 | Domestic Cold Water 1 | 798.223 | 214.287 | Level: Level 1 | 5719.05 | 0.0416667 | 15 mmø | 0.0349738 | 583.936
708226 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 3030 | 38036.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 108 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 484.3
708233 | Level 1 | 0.0122545 | 85661.5 | 2 | 277.674 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 3031 | 14522.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 32 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 184.906
708266 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 3032 | 4509.22 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 107 | 702.529 | Domestic Cold Water 1 | 798.223 | 702.535 | Level: Level 1 | 858.964 | 0.0416667 | 15 mmø | 0.0349738 | 95.6887
708267 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 3033 | 2777.47 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 107 | 682.914 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 58.9397
711692 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 3198 | 13228.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 131 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 280.719
712869 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 3225 | 7766.06 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 519 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 164.801
713111 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 3233 | 8557.53 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 526 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 136.197
713690 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 3258 | 3743.41 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 702 | 3211.9 | Domestic Cold Water 1 | -1350 | -1350 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 59.5781
714210 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 3281 | 9541.92 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 636 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 202.486
719547 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 3493 | 36359.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 620 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 771.568
719762 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 3500 | 73307.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 625 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 1166.73
724039 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 3566 | 400582 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 698 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 6375.45
997489 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 3663 | 45178.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 565 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 958.725
997583 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 3664 | 73752.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 565 | 3090.64 | Domestic Cold Water 1 | -1479.36 | 85.7125 | Level: Level 2 |  | 0.0416667 | 15 mmø | 0.0349738 | 1565.07
1054501 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 4982 | 1783531 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 623 | 3039.88 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.208333 | 65 mmø | 0.197638 | 8734.09
1054505 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 4983 | 85893.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 623 | 3039.88 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.208333 | 65 mmø | 0.197638 | 420.625
1054519 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 4984 | 48863.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 700 | 2989.88 | Domestic Cold Water 1 | -1550 | -1550 | Level: Level 2 | 0 | 0.208333 | 65 mmø | 0.197638 | 239.289
1054694 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 4989 | 12926.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 623 | 3039.88 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.208333 | 65 mmø | 0.197638 | 63.304
1056703 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 4991 | 6989 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 702 | 3211.9 | Domestic Cold Water 1 | -1350 | -1350 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 111.233
1056711 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 4992 | 4387.63 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 702 | 3132.71 | Domestic Cold Water 1 | -1367.46 | -1437.29 | Level: Level 2 |  | 0.0625 | 20 mmø | 0.0531824 | 69.8312
1056713 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 4993 | 18276.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 623 | 3039.88 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.208333 | 65 mmø | 0.197638 | 89.5031
1060518 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 4994 | 1202975 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 258 | -561.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.333333 | 100 mmø | 0.320013 | 3829.19
1076245 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5121 | 955.795 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 705 | 785.55 | Domestic Cold Water 1 | 805.833 | 785.55 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 20.2826
1076247 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5122 | 291.265 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 705 | 765.933 | Domestic Cold Water 1 | 771.263 | 771.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 6.18084
1076258 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5124 | 445.75 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 704 | 765.933 | Domestic Cold Water 1 | 771.263 | 771.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 9.45911
1076850 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5129 | 951.169 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 455 | 785.62 | Domestic Cold Water 1 | 805.833 | 785.649 | Level: Level 1 | 183.856 | 0.0416667 | 15 mmø | 0.0349738 | 20.1844
1076851 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5130 | 1113.56 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 455 | 765.933 | Domestic Cold Water 1 | 771.263 | 771.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 23.6305
1077358 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5140 | 2958.58 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 427 | 743.033 | Domestic Cold Water 1 | 805.833 | 743.05 | Level: Level 1 | 312.546 | 0.0416667 | 15 mmø | 0.0349738 | 62.7831
1077359 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5141 | 5365.62 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 427 | 723.433 | Domestic Cold Water 1 | 728.763 | 728.763 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 113.862
1077562 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 5144 | 52233.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 417 | -492.041 | Domestic Cold Water 1 | 173.012 | -492.041 | Level: Level 1 |  | 0.0833333 | 25 mmø | 0.0740157 | 665.053
1077582 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5145 | 27876 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 712 | 214.283 | Domestic Cold Water 1 | 805.833 | 214.285 | Level: Level 1 | 2231.53 | 0.0416667 | 15 mmø | 0.0349738 | 591.547
1077586 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5146 | 6544.08 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 712 | 194.67 | Domestic Cold Water 1 | 200 | 200 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 138.87
1077958 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5153 | 1191.45 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 444 | 780.522 | Domestic Cold Water 1 | 805.833 | 780.55 | Level: Level 1 | 192.617 | 0.0416667 | 15 mmø | 0.0349738 | 25.2834
1077959 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5154 | 5208.97 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 444 | 760.933 | Domestic Cold Water 1 | 766.263 | 766.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 110.538
1078072 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5159 | 2133.89 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 443 | 760.55 | Domestic Cold Water 1 | 805.833 | 760.55 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 45.2826
1078073 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5160 | 5861.68 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 443 | 740.933 | Domestic Cold Water 1 | 746.263 | 746.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 124.389
1078321 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5164 | 3782.98 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 388 | 725.541 | Domestic Cold Water 1 | 805.833 | 725.556 | Level: Level 1 | 370.94 | 0.0416667 | 15 mmø | 0.0349738 | 80.2774
1078491 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5167 | 1190.78 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 374 | 780.56 | Domestic Cold Water 1 | 805.833 | 780.564 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 25.2692
1078492 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5168 | 7082.57 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 374 | 760.933 | Domestic Cold Water 1 | 766.263 | 766.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 150.297
1078819 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5172 | 19805.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 360 | 385.547 | Domestic Cold Water 1 | 805.833 | 385.55 | Level: Level 1 | 1608.41 | 0.0416667 | 15 mmø | 0.0349738 | 420.283
1078820 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5173 | 6755.65 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 360 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 143.359
1079150 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5179 | 2016.11 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 361 | 763.028 | Domestic Cold Water 1 | 805.833 | 763.05 | Level: Level 1 | 244.292 | 0.0416667 | 15 mmø | 0.0349738 | 42.7832
1079151 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5180 | 3763.41 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 361 | 743.433 | Domestic Cold Water 1 | 748.763 | 748.763 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 79.8621
1079184 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5181 | 3743.99 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 367 | 820.55 | Domestic Cold Water 1 | 820.55 | 900 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 79.45
1079185 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5182 | 4941.88 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 367 | 800.933 | Domestic Cold Water 1 | 806.263 | 806.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 104.87
1079785 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5194 | 1082 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 381 | 782.872 | Domestic Cold Water 1 | 805.833 | 782.872 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 22.9608
1079786 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5195 | 5557.28 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 381 | 763.254 | Domestic Cold Water 1 | 768.584 | 768.584 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 117.929
1079804 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5196 | 3782.98 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 380 | 725.541 | Domestic Cold Water 1 | 805.833 | 725.556 | Level: Level 1 | 370.94 | 0.0416667 | 15 mmø | 0.0349738 | 80.2774
1079805 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5197 | 4236.95 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 380 | 705.933 | Domestic Cold Water 1 | 711.263 | 711.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 89.9109
1079978 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5202 | 1544.31 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 333 | 773.058 | Domestic Cold Water 1 | 805.833 | 773.061 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 32.7713
1079979 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5203 | 4618.05 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 333 | 753.433 | Domestic Cold Water 1 | 758.763 | 758.763 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 97.998
1080391 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5213 | 19805.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 495 | 385.55 | Domestic Cold Water 1 | 805.833 | 385.55 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 420.283
1080392 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5214 | 12168.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 495 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 258.232
1080593 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5216 | 19805.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 500 | 385.548 | Domestic Cold Water 1 | 805.833 | 385.551 | Level: Level 1 | 1593.77 | 0.0416667 | 15 mmø | 0.0349738 | 420.282
1080594 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5217 | 5838.73 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 500 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 123.902
1080880 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5222 | 61460.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 726 | -498.391 | Domestic Cold Water 1 | 805.833 | -498.39 | Level: Level 1 | 4790.4 | 0.0416667 | 15 mmø | 0.0349738 | 1304.22
1080883 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5223 | 3355.24 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 726 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 71.2004
1081265 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5234 | 61460.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 728 | -498.391 | Domestic Cold Water 1 | 805.833 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 1304.22
1081266 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5235 | 1492.52 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 728 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 31.6724
1081527 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5238 | 2837.56 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 730 | 4864.67 | Domestic Cold Water 1 | 300 | 300 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 60.215
1082045 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5247 | 3424.95 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 563 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 72.6797
1082170 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5250 | 1556.54 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 740 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 33.0308
1082306 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5254 | 7297.62 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 565 | 4664.67 | Domestic Cold Water 1 | 100 | 100 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 154.86
1082730 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5267 | 2981.11 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 599 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 63.2612
1082856 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5270 | 1598.66 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 604 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 33.9246
1083019 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5275 | 2877.05 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 614 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 61.053
1083340 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5289 | 7652.63 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 756 | 5064.67 | Domestic Cold Water 1 | 500 | 500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 162.394
1083509 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5293 | 1777.63 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 695 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 37.7225
1084046 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5311 | 1325.65 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 609 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 28.1312
1084471 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 5320 | 179628 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 551 | 3039.88 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.208333 | 65 mmø | 0.197638 | 879.65
1084503 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5322 | 1392.52 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 747 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 29.5502
1084841 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5328 | 7405.24 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 664 | 4764.67 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 157.144
1085038 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5335 | 1935.45 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 667 | 4064.67 | Domestic Cold Water 1 | -500 | -500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 41.0716
1085200 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5340 | 2994.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 661 | 4064.67 | Domestic Cold Water 1 | -500 | -500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 63.5516
1086086 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5358 | 22776.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 752 | 5064.67 | Domestic Cold Water 1 | 500 | 500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 483.337
1086089 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5359 | 3036.27 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 753 | 5064.67 | Domestic Cold Water 1 | 500 | 500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 64.4316
1086452 | Level 1 | 0.0153379 | 143533 | 2 | 1386.19 | 70.6554 | 0.0334201 | 0.25 | 2944.88 | 44127.6 | 5363 | 300.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0328084 | 54 | 904.979 | Domestic Cold Water 1 | 908.719 | 908.719 | Level: Level 1 | 0 | 0.0312336 | 10 mmø | 0.0245407 | 9.57477
1086465 | Level 1 | 0.0153379 | 143533 | 2 | 1386.19 | 70.6554 | 0.0334201 | 0.25 | 2944.88 | 44127.6 | 5365 | 300.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0328084 | 60 | 904.979 | Domestic Cold Water 1 | 908.719 | 908.719 | Level: Level 1 | 0 | 0.0312336 | 10 mmø | 0.0245407 | 9.57477
1086466 | Level 1 | 0.0153379 | 143533 | 2 | 7253.14 | 70.6554 | 0.0334201 | 0.25 | 2944.88 | 44127.6 | 5366 | 1573.91 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0328084 | 54 | 904.979 | Domestic Cold Water 1 | 908.719 | 908.719 | Level: Level 1 | 0 | 0.0312336 | 10 mmø | 0.0245407 | 50.0992
1086488 | Level 1 | 0.0153379 | 143533 | 2 | 4645.59 | 70.6554 | 0.0334201 | 0.25 | 2944.88 | 44127.6 | 5368 | 1008.08 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0328084 | 60 | 904.979 | Domestic Cold Water 1 | 908.719 | 908.719 | Level: Level 1 | 0 | 0.0312336 | 10 mmø | 0.0245407 | 32.0883
1098055 | Level 1 | 0.0142324 | 100715 | 2 | 580.45 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 5400 | 1196.95 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 62 | 350.195 | Domestic Cold Water 1 | 355.525 | 355.525 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 25.4
1098058 | Level 1 | 0.0142324 | 100715 | 2 | 1759.79 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 5401 | 3628.86 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 62 | 350.195 | Domestic Cold Water 1 | 355.525 | 355.525 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 77.0067
1098062 | Level 1 | 0.0142324 | 100715 | 2 | 18988 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 5402 | 39155.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 62 | -489.659 | Domestic Cold Water 1 | 341.238 | -489.659 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 830.897
1098234 | Level 1 | 0.0142324 | 100715 | 2 | 1426.44 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 5406 | 2941.45 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 67 | 350.195 | Domestic Cold Water 1 | 355.525 | 355.525 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 62.4196
1098236 | Level 1 | 0.0142324 | 100715 | 2 | 3873.3 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 5407 | 7987.14 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 67 | 350.195 | Domestic Cold Water 1 | 355.525 | 355.525 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 169.492
1098494 | Level 1 | 0.0142324 | 100715 | 2 | 585.714 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 5417 | 1207.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 69 | 350.195 | Domestic Cold Water 1 | 355.525 | 355.525 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 25.6303
1098496 | Level 1 | 0.0142324 | 100715 | 2 | 2311.51 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 5418 | 4766.57 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 69 | 350.195 | Domestic Cold Water 1 | 355.525 | 355.525 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 101.15
1098751 | Level 2 | 0.0142324 | 100715 | 2 | 580.45 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 5422 | 1196.95 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 73 | 4920.2 | Domestic Cold Water 1 | 355.525 | 355.525 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 25.4
1098752 | Level 2 | 0.0142324 | 100715 | 2 | 340.771 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 5423 | 702.705 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 73 | 4920.2 | Domestic Cold Water 1 | 355.525 | 355.525 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 14.9119
1098755 | Level 2 | 0.0142324 | 100715 | 2 | 41750.1 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 5424 | 86093 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 73 | 3084.29 | Domestic Cold Water 1 | 341.238 | -1485.71 | Level: Level 2 |  | 0.0416667 | 15 mmø | 0.0349738 | 1826.95
1099052 | Level 2 | 0.0142324 | 100715 | 2 | 1297.49 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 5430 | 2675.55 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 75 | 4920.2 | Domestic Cold Water 1 | 355.525 | 355.525 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 56.777
1099054 | Level 2 | 0.0142324 | 100715 | 2 | 2901.11 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 5431 | 5982.38 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 75 | 4784.29 | Domestic Cold Water 1 | 341.238 | 214.288 | Level: Level 2 |  | 0.0416667 | 15 mmø | 0.0349738 | 126.95
1099320 | Level 1 | 0.0142324 | 100715 | 2 | 1108.53 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 5435 | 2285.91 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 79 | 350.195 | Domestic Cold Water 1 | 355.525 | 355.525 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 48.5085
1099321 | Level 1 | 0.0142324 | 100715 | 2 | 2278.48 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 5436 | 4698.45 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 79 | 350.195 | Domestic Cold Water 1 | 355.525 | 355.525 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 99.7041
1127261 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 5576 | 15060.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 700 | 3039.88 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.208333 | 65 mmø | 0.197638 | 73.7521
1127262 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 5577 | 7725.53 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 700 | 3010.33 | Domestic Cold Water 1 | -1538.38 | -1511.62 | Level: Level 2 | 1 | 0.208333 | 65 mmø | 0.197638 | 37.8325
1184486 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5641 | 16703 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 388 | 705.933 | Domestic Cold Water 1 | 711.263 | 711.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 354.449
1184488 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5642 | 7116.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 388 | 705.933 | Domestic Cold Water 1 | 711.263 | 711.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 151.015
1186991 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5645 | 3124.97 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 2 | 739.519 | Domestic Cold Water 1 2 | 739.519 | 805.833 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 66.3139
1205103 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5697 | 5797.42 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 216 | 928.687 | Domestic Cold Water 1 | 1051.71 | 928.688 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 123.025
1205145 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5698 | 1386.98 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 216 | 1060.67 | Domestic Cold Water 1 | 1066 | 1066 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 29.4326
1205161 | Level 1 | 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 5699 | 1013.41 |  | 0 |  |  | 0.0416667 | 215 | 1059.65 | Domestic Cold Water 1 | 1066 | 1066 | Level: Level 1 | 0 | 0.0416667 | 13 mmø | 0.0416667 | 25.4
1205162 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 5700 | 2655.73 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 216 | 1060.67 | Domestic Cold Water 1 | 1066 | 1066 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 56.3562

# IfcFlowSegment: Pipe Types:Hot Water:699832 (871)
Type - ElementType: Pipe Types:Hot Water:699832
Identity Data - Manufacturer: N/A
Text - LeakageCurve: 0; WorkingPressure: 0; TemperatureRange: 0; FluidFlowLeakage: 0; PressureRange: 0; InteriorRoughnessCoefficient: 0; OuterDiameter: 1; Gradient: 0; InnerDiameter: 1; InvertElevation: 1; NominalDiameter: 1
Other - NominalWidth: 0; Shape: N/A; Constituents: N/A; WarrantyDescription: N/A; Material: Material; Reference: Type A - 1; NominalLength: 0; Color: White; Grade: N/A; ProductionYear: N/A; WarrantyGuarantorLabor: N/A; Size: Size; WarrantyDurationParts: N/A; ReplacementCost: N/A; CodePerformance: N/A; Features: N/A; WarrantyDurationLabor: N/A; WarrantyGuarantorParts: N/A; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; NominalHeight: 0; AccessibilityPerformance: N/A; AssetAccountingType: FIXED; SustainabilityPerformance: N/A; ExpectedLife: N/A; ModelReference: N/A; ModelLabel: N/A; BarCode: N/A; TagNumber: N/A; SerialNumber: N/A; WarrantyStartDate: N/A; InstallationDate: N/A; AssetIdentifier: N/A
Mechanical - Schedule/Type: Pipe Schedule Types: A; Connection Type: Generic; Pipe Segment: Copper - A; Roughness: 0.00000833333; Material: Copper
Constraints - Vertical Justification: 0; Horizontal Justification: 0
Mechanical - Flow - Additional Flow: 0
Phasing - Phase Created: New Construction
Name (Pipe Types:Hot Water:...) | In | System Type | Invert Elevation (mm) | System Name | System Classification | Area (mm2) | Diameter | Section | Offset (mm) = Start Offset (mm) | Slope | End Offset (mm) | Reference Level | Reynolds Number | Flow State | Friction | Relative Roughness | Velocity | Friction Factor | Pressure Drop | Fixture Units | Flow | Inner Diameter | Size = Overall Size | Length (mm) | Outer Diameter | Mark
699832 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 668403 | 0.0656168 | 236 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 10638 | 0.0625 | 2631
699892 | Level 1 | Piping System: Domestic Hot Water 1 | -282.538 | Domestic Hot Water 1 | Domestic Hot Water | 29221.5 | 0.0656168 | 236 | -282.538 |  | 182.538 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 465.075 | 0.0625 | 2633
699932 | Level 1 | Piping System: Domestic Hot Water 1 | 191.895 | Domestic Hot Water 1 | Domestic Hot Water | 52047.7 | 0.0656168 | 595 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 828.365 | 0.0625 | 2636
699936 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 22950.8 | 0.082021 | 257 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 292.219 | 0.0833333 | 2637
700028 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 12540.3 | 0.0656168 | 234 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 199.585 | 0.0625 | 2639
700074 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 37403.5 | 0.082021 | 238 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 476.236 | 0.0833333 | 2640
700122 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 18733.2 | 0.0492126 | 176 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 397.532 | 0.0416667 | 2641
700132 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 211854 | 0.082021 | 237 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 2697.4 | 0.0833333 | 2642
700136 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 11444.6 | 0.0492126 | 176 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 242.863 | 0.0416667 | 2643
700141 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 5227.4 | 0.0492126 | 176 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 110.929 | 0.0416667 | 2644
700177 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 26927.8 | 0.0492126 | 176 | -285.713 |  | 285.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 571.425 | 0.0416667 | 2645
700182 | Level 1 | Piping System: Domestic Hot Water 1 | 314.289 | Domestic Hot Water 1 | Domestic Hot Water | 22804.8 | 0.0492126 | 176 | 314.29 | 4351.01 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 483.933 | 0.0416667 | 2646
700246 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 24587.5 | 0.0492126 | 178 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 521.762 | 0.0416667 | 2647
700310 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 142873 | 0.0656168 | 241 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 2273.9 | 0.0625 | 2648
700319 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 20265.6 | 0.0656168 | 239 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 322.538 | 0.0625 | 2649
700336 | Level 1 | Piping System: Domestic Hot Water 1 | -358.105 | Domestic Hot Water 1 | Domestic Hot Water | 54401.8 | 0.0656168 | 140 | -350 | 0 | -350 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 865.832 | 0.0625 | 2650
700367 | Level 1 | Piping System: Domestic Hot Water 1 | -358.105 | Domestic Hot Water 1 | Domestic Hot Water | 37614.5 | 0.0656168 | 140 | -350 | 0 | -350 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 598.653 | 0.0625 | 2651
700402 | Level 1 | Piping System: Domestic Hot Water 1 | -358.105 | Domestic Hot Water 1 | Domestic Hot Water | 37619 | 0.0656168 | 240 | -350 | 0 | -350 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 598.725 | 0.0625 | 2652
700409 | Level 1 | Piping System: Domestic Hot Water 1 | -358.105 | Domestic Hot Water 1 | Domestic Hot Water | 82411.4 | 0.0656168 | 239 | -350 | 0 | -350 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1311.62 | 0.0625 | 2653
700411 | Level 1 | Piping System: Domestic Hot Water 1 | 191.895 | Domestic Hot Water 1 | Domestic Hot Water | 3929.35 | 0.0656168 | 240 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 62.5375 | 0.0625 | 2654
700444 | Level 1 | Piping System: Domestic Hot Water 1 | -332.538 | Domestic Hot Water 1 | Domestic Hot Water | 32363.1 | 0.0656168 | 240 | -332.538 |  | 182.538 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 515.075 | 0.0625 | 2655
700491 | Level 1 | Piping System: Domestic Hot Water 1 | 191.895 | Domestic Hot Water 1 | Domestic Hot Water | 7065.39 | 0.0656168 | 140 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 112.449 | 0.0625 | 2656
700498 | Level 1 | Piping System: Domestic Hot Water 1 | -332.538 | Domestic Hot Water 1 | Domestic Hot Water | 32363.1 | 0.0656168 | 140 | -332.538 |  | 182.538 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 515.075 | 0.0625 | 2657
700502 | Level 1 | Piping System: Domestic Hot Water 1 | 191.895 | Domestic Hot Water 1 | Domestic Hot Water | 3409.47 | 0.0656168 | 140 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 54.2634 | 0.0625 | 2658
700510 | Level 1 | Piping System: Domestic Hot Water 1 | 214.289 | Domestic Hot Water 1 | Domestic Hot Water | 27517.2 | 0.0492126 | 139 | 214.29 | 5212.45 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 583.934 | 0.0416667 | 2659
700572 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 35040.7 | 0.0656168 | 241 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 557.689 | 0.0625 | 2660
700586 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 46520.7 | 0.0492126 | 246 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 987.199 | 0.0416667 | 2661
700593 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 540240 | 0.0656168 | 242 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 8598.18 | 0.0625 | 2662
700597 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 48369.1 | 0.0492126 | 246 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1026.43 | 0.0416667 | 2663
