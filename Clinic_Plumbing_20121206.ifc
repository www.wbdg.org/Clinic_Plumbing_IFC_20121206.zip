Properties of the parts of a building model (IFC2X3), part 3 of 29

# IfcFlowFitting: Elbow - Generic (1654)
Name (M_Elbow - Generic:Elbow - Generic:Elbow - Generic:...) | In | Offset (mm) | Level | Host | Fitting Outside Radius = Insulation Radius | Center Radius | Overall Size = Size | System Classification | Loss Method | System Type | System Name | Angle (deg) | Nominal Radius | Center to End | Fitting Outside Diameter | Tick Size | Nominal Diameter | Mark
644938 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2877
644946 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 2879
644958 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2882
644960 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2884
645231 | Level 1 | 600 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2889
645359 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2899
645367 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 2902
645386 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 60 | 0.082021 | 0.0631477 | 0.177083 | 0.0408956 | 0.164042 | 2908
645392 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 30 | 0.082021 | 0.0293069 | 0.177083 | 0.0189797 | 0.164042 | 2909
645402 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2910
645546 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2920
645566 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2926
645740 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2945
645742 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2947
645750 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.0656168 | 0.0366752 | 0.135417 | 0.0224366 | 0.131234 | 2949
645871 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 2984
645873 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 75.6104 | 0.0524934 | 0.0606113 | 0.114583 | 0.0355586 | 0.104987 | 2986
645921 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 2988
645958 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 2997
645960 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 58.9176 | 0.0524934 | 0.0441268 | 0.114583 | 0.0258877 | 0.104987 | 2999
646101 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 3011
646117 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 35 | 0.0524934 | 0.0246327 | 0.114583 | 0.0144512 | 0.104987 | 3017
646204 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3041
646238 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3046
646278 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3054
646397 | TOF Footing | -501.082 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3066
646399 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3068
646434 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3082
646436 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 38.0376 | 0.0656168 | 0.0305198 | 0.135417 | 0.018671 | 0.131234 | 3084
646636 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 38.5417 | 0.0656168 | 0.0309563 | 0.135417 | 0.018938 | 0.131234 | 3113
646736 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 3121
646921 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3135
646923 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3137
646935 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 35 | 0.0656168 | 0.0279171 | 0.135417 | 0.0170787 | 0.131234 | 3142
646970 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3145
647045 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 3152
647182 | Level 1 | 3000 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.0656168 | 0.0366752 | 0.135417 | 0.0224366 | 0.131234 | 3163
647248 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3169
647250 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3171
647270 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.0656168 | 0.0366752 | 0.135417 | 0.0224366 | 0.131234 | 3173
647354 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 3175
647479 | Level 1 | 232.932 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3192
647517 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 3199
647582 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 35.8737 | 0.082021 | 0.0354049 | 0.177083 | 0.0229289 | 0.164042 | 3212
647583 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 3213
647704 | Level 1 | 0 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90.0329 | 0.082021 | 0.109438 | 0.177083 | 0.070874 | 0.164042 | 3221
647761 | Level 1 | 0 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 3225
647784 | Level 1 | 1000 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 3231
647820 | Level 1 | 0 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 3235
647887 | Level 1 | 0 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3239
647888 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3240
647914 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3243
647948 | Level 1 | 4000 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 |  |  | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3245
648149 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3258
648433 | Level 1 | 0 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 3275
648435 | Level 1 | 2800 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 3277
648502 | Level 1 | 2800 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 3279
653979 | Level 1 | -411 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3308
653981 | Level 1 | -411 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 3310
654013 | Level 1 | -411 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 3311
654025 | Level 1 | -411 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3318
654341 | Level 1 | -411 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3352
654457 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 3356
654512 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3360
654599 | Level 1 | -411 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 3365
654614 | Level 1 | -411 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 3366
654925 | Level 1 | 4370 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 3385
654927 | Level 1 | -200 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 59.3208 | 0.082021 | 0.0622862 | 0.177083 | 0.0403377 | 0.164042 | 3387
654987 | Level 1 | -200 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 35 | 0.082021 | 0.0344858 | 0.177083 | 0.0223337 | 0.164042 | 3388
655122 | Level 1 | 0 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 3401
655170 | Level 1 | 0 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3407
655208 | Level 1 | 4159 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3411
655272 | Level 1 | -411 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 3417
655309 | Level 1 | -411 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 3418
655345 | Level 2 | 232.932 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3420
655347 | Level 1 | -411 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3422
655349 | Level 1 | -411 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3424
655390 | Level 1 | -411 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 3429
655425 | Level 2 | 232.932 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3430
655432 | Level 1 | -411 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3436
655506 | Level 1 | -200 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3448
655611 | Level 1 | -200 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3472
655790 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3482
655932 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 3493
655943 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 3496
655945 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 3498
656089 | Level 1 | 2881.8 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3509
656091 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3511
656245 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.131234 | 0.0625635 | 0.260417 | 0.0431472 | 0.262467 | 3518
656376 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.131234 | 0.151042 | 0.260417 | 0.104167 | 0.262467 | 3525
656453 | Level 1 | 100 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 3538
656522 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 3550
656530 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.0524934 | 0.0323604 | 0.114583 | 0.0189848 | 0.104987 | 3552
656639 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 3558
656929 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3578
657001 | Level 1 | -1682.2 | Level: Level 2 | Level : Level 2 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.131234 | 0.151042 | 0.260417 | 0.104167 | 0.262467 | 3593
657102 | Level 1 | -1682.2 | Level: Level 2 | Level : Level 2 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.131234 | 0.151042 | 0.260417 | 0.104167 | 0.262467 | 3597
657103 | Level 1 | -1682.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 3598
657209 | Level 1 | 3100 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 3614
657265 | Level 1 | 3100 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 3618
657266 | Level 1 | 3100 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 3619
657589 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 3622
657670 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 3625
657729 | Level 1 | 3170 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 3635
657776 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 25 | 0.164042 | 0.0427224 | 0.34375 | 0.030483 | 0.328084 | 3637
657868 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3639
658030 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3654
658096 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 3659
658101 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 3660
658159 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3664
658213 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 3669
658222 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 3670
658329 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 3683
658392 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 3690
658441 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3693
658562 | Level 1 | 3170 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 3717
658591 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 3724
658739 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 3741
659074 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 3770
659107 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3771
659116 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3777
659118 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3779
659225 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.131234 | 0.151042 | 0.260417 | 0.104167 | 0.262467 | 3786
659253 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 3799
659260 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 3801
659355 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3804
659578 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.131234 | 0.0625635 | 0.260417 | 0.0431472 | 0.262467 | 3822
659650 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 3824
659752 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 3843
659993 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 3861
660116 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 3890
660241 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 3891
660289 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 3904
660352 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3909
660391 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 3917
660433 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3918
660483 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3922
660593 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3928
660632 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3932
660633 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 3933
660671 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.131234 | 0.0625635 | 0.260417 | 0.0431472 | 0.262467 | 3942
660846 | Level 1 | 3000 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3980
660848 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 3982
660862 | Level 1 | 3000 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 3985
660880 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.131234 | 0.0625635 | 0.260417 | 0.0431472 | 0.262467 | 3986
660992 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 3999
661030 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 4002
661048 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 4004
661077 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.131234 | 0.151042 | 0.260417 | 0.104167 | 0.262467 | 4006
661095 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.131234 | 0.151042 | 0.260417 | 0.104167 | 0.262467 | 4008
661125 | Level 2 | 500 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 4017
661135 | Level 2 | 500 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 4020
661137 | Level 2 | 500 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 37.0262 | 0.082021 | 0.0366241 | 0.177083 | 0.0237185 | 0.164042 | 4022
661163 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 4027
661250 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 4036
661481 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 4058
661487 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 4060
661834 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.131234 | 0.151042 | 0.260417 | 0.104167 | 0.262467 | 4112
661873 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 4120
661958 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 4133
662043 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.131234 | 0.151042 | 0.260417 | 0.104167 | 0.262467 | 4143
662080 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 4151
662135 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 4166
662309 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 4189
662437 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 4206
662555 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 4219
662578 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 4223
662612 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 4228
662690 | Level 2 | 500 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 4241
662848 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 4250
663051 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 4286
663081 | Level 1 | 0 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 4292
663188 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 4306
663231 | Level 1 | 3000 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 4307
663257 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 4308
663270 | Level 1 | 0 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 4309
663307 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 4310
663345 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 4312
663456 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 4318
663512 | Level 1 | -200 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 4320
663637 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 4324
663667 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 4325
663685 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 4327
663877 | Level 1 | 2881.8 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 4341
663949 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 44.1372 | 0.164042 | 0.0781277 | 0.34375 | 0.0557452 | 0.328084 | 4350
664042 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 4351
664226 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.131234 | 0.151042 | 0.260417 | 0.104167 | 0.262467 | 4374
664227 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.131234 | 0.0625635 | 0.260417 | 0.0431472 | 0.262467 | 4375
664297 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.0656168 | 0.0366752 | 0.135417 | 0.0224366 | 0.131234 | 4390
664319 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 4401
664321 | Level 1 | -1400 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 65 | 0.0656168 | 0.0564073 | 0.135417 | 0.034508 | 0.131234 | 4403
664344 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 4412
664468 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 4434
664486 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 4436
664530 | Level 2 | 5070 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 4447
664940 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 4476
665068 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 4499
665160 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 4513
665181 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 4516
665183 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 4518
665248 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 4525
665741 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 4555
665863 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 4561
665885 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 4567
665922 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 4573
666097 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 4584
666116 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 4587
666177 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 4597
666210 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 4609
666413 | Level 1 | -1560 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 4629
666494 | Level 1 | -1560 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 4638
666523 | Level 1 | -1560 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 4641
666537 | Level 1 | -1560 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 4644
666605 | Level 1 | -1560 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 4656
666622 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 4659
666823 | Level 1 | -1560 | Level: Level 2 | Level : Level 2 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 4702
666826 | Level 1 | -1560 | Level: Level 2 | Level : Level 2 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.131234 | 0.0625635 | 0.260417 | 0.0431472 | 0.262467 | 4704
666841 | Level 1 | -1560 | Level: Level 2 | Level : Level 2 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 4707
667086 | Level 1 | -1560 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 4740
667151 | Level 1 | -1560 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 4747
667386 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 4772
669577 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 4800
669626 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 4804
677573 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.109375 | 0.130208 | 65 mmø-65 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.106627 | 0.130208 | 0.21875 | 0.0875 | 0.213255 | 4882
677578 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.109375 | 0.130208 | 65 mmø-65 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.106627 | 0.130208 | 0.21875 | 0.0875 | 0.213255 | 4883
677730 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 4908
677739 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 4910
677796 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 4918
678269 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 4935
678271 | Level 1 | 500 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 4937
678299 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 4939
678300 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 4940
678832 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 4965
678840 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 4967
678880 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 4970
678882 | Level 1 | 500 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 4972
678957 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 4978
679213 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5005
679262 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5006
679376 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.109375 | 0.130208 | 65 mmø-65 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.106627 | 0.130208 | 0.21875 | 0.0875 | 0.213255 | 5023
679428 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 5042
679435 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 5043
679491 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 5045
679573 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5054
679574 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5055
679597 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5066
679867 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 5079
679869 | Level 1 | 500 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 5081
680053 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5092
680083 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5095
680114 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5100
680119 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5105
680268 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 5121
680320 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5127
680321 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5128
680343 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5138
680491 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5146
680492 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5147
680498 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5149
