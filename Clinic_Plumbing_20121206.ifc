Properties of the parts of a building model (IFC2X3), part 5 of 29

# IfcFlowFitting: Elbow - Generic (1654)
Name (M_Elbow - Generic:Elbow - Generic:Elbow - Generic:...) | In | Offset (mm) | Level | Host | Fitting Outside Radius = Insulation Radius | Center Radius | Overall Size = Size | System Classification | Loss Method | System Type | System Name | Angle (deg) | Nominal Radius | Center to End | Fitting Outside Diameter | Tick Size | Nominal Diameter | Mark
695470 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6832
695478 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6838
695905 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 6848
695920 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 6850
696024 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 6858
696039 | Level 2 | 500 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 6861
696047 | Level 2 | 500 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 6863
696059 | Level 2 | 500 | Level: Level 2 | Level : Level 2 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 6864
696085 | Level 2 | 500 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 6872
696093 | Level 2 | 500 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 6874
696142 | Level 2 | 500 | Level: Level 2 | Level : Level 2 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 6875
696266 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 6900
696321 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 6904
696347 | Level 2 | 500 | Level: Level 2 | Level : Level 2 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 6908
696350 | Level 2 | 500 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 6910
696368 | Level 2 | 500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6916
696390 | Level 2 | 500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6923
696421 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6928
696633 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6940
696772 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6955
696877 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6972
697037 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6994
697172 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7011
697290 | Level 2 | 500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7021
697362 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7035
697686 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7079
697746 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7086
697754 | Level 2 | 500.005 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7092
697772 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 7098
697886 | Level 1 | 3070 | Level: Level 1 | Level : Level 1 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.131234 | 0.151042 | 0.260417 | 0.104167 | 0.262467 | 7102
697956 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.131234 | 0.151042 | 0.260417 | 0.104167 | 0.262467 | 7108
698145 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7123
698216 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7128
698217 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7129
698369 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7136
698399 | Level 1 | -1560 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 7148
698522 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7180
698552 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7183
698592 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7185
698593 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7186
698761 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 79.9581 | 0.0246063 | 0.0393036 | 0.0520833 | 0.0174683 | 0.0492126 | 7204
698874 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7220
698875 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7221
698895 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7225
698927 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 7241
698965 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 7250
698985 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 7258
699011 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7271
699037 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7272
699038 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7273
699140 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7284
699418 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 7292
699439 | Level 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 7302
699463 | Level 1 | -500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7311
699582 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7329
699583 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7330
699609 | Level 1 | -500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7340
699893 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7361
699950 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 7374
700140 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7383
700178 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7385
700185 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7390
700335 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7397
700366 | TOF Footing | -350 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7399
700379 | TOF Footing | -350 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7402
700445 | TOF Footing | -350 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7407
700446 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7408
700499 | TOF Footing | -350 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7410
700500 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7411
700513 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7416
700605 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7425
700654 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7426
700655 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7427
700875 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7443
700877 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7445
700888 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7450
701019 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7464
701021 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7466
701122 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7476
701132 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7480
701142 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7482
701146 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 7486
701147 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 7487
701158 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7490
701162 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 7494
701163 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 7495
701429 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7511
701504 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7515
701505 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7516
701521 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7523
701729 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7543
701794 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7544
701795 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7545
701808 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7550
701889 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7559
701890 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7560
701946 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7571
701947 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7572
702164 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 7583
702194 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 7586
702232 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7596
702279 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7597
702280 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7598
702293 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7603
702368 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 7606
702480 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7643
702609 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7652
702632 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7660
702647 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7665
702678 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7676
702723 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7679
702724 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7680
702849 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7696
702981 | TOF Footing | -350 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7716
702982 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7717
703090 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7723
703091 | TOF Footing | -350 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7724
703135 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7726
703139 | TOF Footing | -350 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7730
703140 | TOF Footing | -350 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7731
703194 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7734
703199 | TOF Footing | -350 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7738
703257 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7742
703297 | TOF Footing | -350 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7747
703360 | TOF Footing | -350 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7751
703501 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7776
703502 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7777
703563 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 7783
703564 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 7784
703596 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 7791
703597 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 7792
703630 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7794
703758 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7809
703760 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7811
703766 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7813
703845 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7816
703846 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7817
703894 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7827
703941 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7829
703942 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7830
704015 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7842
704081 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7843
704152 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7857
704207 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7871
704224 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7872
704252 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7874
704253 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7875
704264 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7880
704403 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7887
704427 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7890
704432 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7891
704621 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7906
704622 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7907
704655 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 7911
704913 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 45 | 0.0524934 | 0.0323604 | 0.114583 | 0.0189848 | 0.104987 | 7915
704915 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 45 | 0.0524934 | 0.0323604 | 0.114583 | 0.0189848 | 0.104987 | 7917
704933 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 7923
704975 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7935
705037 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7941
705038 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7942
705090 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7948
705140 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7954
705141 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7955
705152 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7960
705241 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7967
705242 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7968
705262 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 44.536 | 0.082021 | 0.0447866 | 0.177083 | 0.0290046 | 0.164042 | 7977
705267 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 7978
705295 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 7984
705421 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8002
705524 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8006
705525 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8007
705550 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 45 | 0.0246063 | 0.0194163 | 0.0520833 | 0.00862945 | 0.0492126 | 8016
705552 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 45 | 0.0246063 | 0.0194163 | 0.0520833 | 0.00862945 | 0.0492126 | 8018
705605 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8022
705606 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8023
705622 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8030
705760 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 45 | 0.0524934 | 0.0323604 | 0.114583 | 0.0189848 | 0.104987 | 8035
705762 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 45 | 0.0524934 | 0.0323604 | 0.114583 | 0.0189848 | 0.104987 | 8037
705784 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 8044
705814 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 8046
706012 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8058
706023 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8061
706085 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8062
706086 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8063
706099 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8068
706206 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 8074
706240 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 8076
706241 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 8077
706254 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 8082
706407 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8093
706408 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8094
706419 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8099
706542 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8106
706702 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8117
706729 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8119
706730 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8120
706743 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8125
706792 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8128
706801 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8129
706866 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8136
706867 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8137
706878 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8142
707015 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8153
707045 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8155
707046 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8156
707057 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8161
707201 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 8188
707264 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8197
707309 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 8210
707363 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8226
707368 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8227
707403 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8229
707404 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8230
707415 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8235
707441 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8240
707485 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8247
707486 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8248
707501 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8253
707646 | TOF Footing | -250 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8261
707807 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8274
707808 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8275
707819 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8280
707917 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 8304
708013 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8314
708063 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8323
708064 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8324
708075 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 8329
708110 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8336
708145 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8339
708146 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8340
708157 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 8345
