Properties of the parts of a building model (IFC2X3), part 25 of 29

# IfcFlowSegment: Pipe Types:Hot Water:699832 (871)
Name (Pipe Types:Hot Water:...) | In | System Type | Invert Elevation (mm) | System Name | System Classification | Area (mm2) | Diameter | Section | Offset (mm) = Start Offset (mm) | Slope | End Offset (mm) | Reference Level | Reynolds Number | Flow State | Friction | Relative Roughness | Velocity | Friction Factor | Pressure Drop | Fixture Units | Flow | Inner Diameter | Size = Overall Size | Length (mm) | Outer Diameter | Mark
1078511 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 5129.3 | 0.0492126 | 298 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 108.847 | 0.0416667 | 5170
1078834 | Level 1 | Piping System: Domestic Hot Water 1 | 214.288 | Domestic Hot Water 1 | Domestic Hot Water | 27875.9 | 0.0492126 | 280 | 214.288 |  | 805.833 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 591.545 | 0.0416667 | 5174
1078835 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 7497.08 | 0.0492126 | 280 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 159.093 | 0.0416667 | 5175
1079199 | Level 1 | Piping System: Domestic Hot Water 1 | 314.285 | Domestic Hot Water 1 | Domestic Hot Water | 23163.5 | 0.0492126 | 587 | 314.288 | 1866.69 | 805.833 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 491.545 | 0.0416667 | 5183
1079200 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 2385.87 | 0.0492126 | 587 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 50.6298 | 0.0416667 | 5184
1079214 | Level 1 | Piping System: Domestic Hot Water 1 | 314.288 | Domestic Hot Water 1 | Domestic Hot Water | 23163.5 | 0.0492126 | 588 | 314.289 | 13749.1 | 805.833 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 491.544 | 0.0416667 | 5185
1079215 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 6860.2 | 0.0492126 | 588 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 145.578 | 0.0416667 | 5186
1079222 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 14734.5 | 0.0492126 | 286 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 312.675 | 0.0416667 | 5188
1079762 | Level 1 | Piping System: Domestic Hot Water 1 | 314.285 | Domestic Hot Water 1 | Domestic Hot Water | 23163.5 | 0.0492126 | 308 | 314.288 | 1866.69 | 805.833 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 491.545 | 0.0416667 | 5192
1079763 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 4857.16 | 0.0492126 | 308 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 103.072 | 0.0416667 | 5193
1079823 | Level 1 | Piping System: Domestic Hot Water 1 | 314.288 | Domestic Hot Water 1 | Domestic Hot Water | 23163.5 | 0.0492126 | 305 | 314.289 | 13749.1 | 805.833 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 491.544 | 0.0416667 | 5198
1079824 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 3875.24 | 0.0492126 | 305 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 82.2351 | 0.0416667 | 5199
1079962 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 5492.78 | 0.0492126 | 246 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 116.56 | 0.0416667 | 5201
1080372 | Level 1 | Piping System: Domestic Hot Water 1 | 314.286 | Domestic Hot Water 1 | Domestic Hot Water | 23163.5 | 0.0492126 | 322 | 314.289 | 1851 | 805.833 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 491.544 | 0.0416667 | 5211
1080373 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 12701.8 | 0.0492126 | 322 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 269.54 | 0.0416667 | 5212
1080612 | Level 1 | Piping System: Domestic Hot Water 1 | 314.288 | Domestic Hot Water 1 | Domestic Hot Water | 23163.5 | 0.0492126 | 333 | 314.289 | 13749.1 | 805.833 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 491.544 | 0.0416667 | 5218
1080613 | Level 1 | Piping System: Domestic Hot Water 1 | 294.67 | Domestic Hot Water 1 | Domestic Hot Water | 5645.56 | 0.0492126 | 333 | 300 | 0 | 300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 119.803 | 0.0416667 | 5219
1080903 | Level 1 | Piping System: Domestic Hot Water 1 | 214.288 | Domestic Hot Water 1 | Domestic Hot Water | 27875.9 | 0.0492126 | 597 | 214.288 |  | 805.833 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 591.545 | 0.0416667 | 5224
1080904 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 9978.08 | 0.0492126 | 597 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 211.742 | 0.0416667 | 5225
1080915 | Level 1 | Piping System: Domestic Hot Water 1 | 191.895 | Domestic Hot Water 1 | Domestic Hot Water | 93402.5 | 0.0656168 | 236 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1486.55 | 0.0625 | 5227
1081008 | Level 1 | Piping System: Domestic Hot Water 1 | -355.33 | Domestic Hot Water 1 | Domestic Hot Water | 21402.6 | 0.0492126 | 598 | -350 | 0 | -350 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 454.178 | 0.0416667 | 5228
1081070 | Level 1 | Piping System: Domestic Hot Water 1 | -355.33 | Domestic Hot Water 1 | Domestic Hot Water | 40301.2 | 0.0492126 | 599 | -350 | 0 | -350 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 855.217 | 0.0416667 | 5229
1081202 | Level 1 | Piping System: Domestic Hot Water 1 | -335.714 | Domestic Hot Water 1 | Domestic Hot Water | 53794.1 | 0.0492126 | 599 | -335.712 | 4236.78 | 805.833 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1141.55 | 0.0416667 | 5232
1081203 | Level 1 | Piping System: Domestic Hot Water 1 | -355.33 | Domestic Hot Water 1 | Domestic Hot Water | 4470.32 | 0.0492126 | 599 | -350 | 0 | -350 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 94.863 | 0.0416667 | 5233
1081544 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 738.583 | 0.0492126 | 604 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 15.6732 | 0.0416667 | 5240
1081555 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 21662.6 | 0.0492126 | 491 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 459.695 | 0.0416667 | 5242
1082018 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 5145.15 | 0.0492126 | 518 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 109.183 | 0.0416667 | 5245
1082190 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 3176.51 | 0.0492126 | 513 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 67.4076 | 0.0416667 | 5252
1082321 | Level 2 | Piping System: Domestic Hot Water 1 | 4664.67 | Domestic Hot Water 1 | Domestic Hot Water | 4499.58 | 0.0492126 | 523 | 100 | 0 | 100 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 95.4841 | 0.0416667 | 5256
1082556 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 3987.44 | 0.0492126 | 529 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 84.6161 | 0.0416667 | 5262
1082715 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 3128.94 | 0.0492126 | 540 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 66.3982 | 0.0416667 | 5265
1082875 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 6011.86 | 0.0492126 | 545 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 127.576 | 0.0416667 | 5272
1083036 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 1714.45 | 0.0492126 | 555 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 36.3818 | 0.0416667 | 5277
1083131 | Level 2 | Piping System: Domestic Cold Water 1 | 3064.67 | Domestic Cold Water 1 | Domestic Cold Water | 5309.68 | 0.0492126 | 756 | -1500 | 0 | -1500 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 112.675 | 0.0416667 | 5279
1083140 | Level 2 | Piping System: Domestic Cold Water 1 | 3064.67 | Domestic Cold Water 1 | Domestic Cold Water | 60039 | 0.0492126 | 617 | -1500 | 0 | -1500 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1274.07 | 0.0416667 | 5281
1083155 | Level 2 | Piping System: Domestic Hot Water 1 | 3114.67 | Domestic Hot Water 1 | Domestic Hot Water | 30959.2 | 0.0492126 | 615 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 656.975 | 0.0416667 | 5283
1083162 | Level 2 | Piping System: Domestic Hot Water 1 | 3114.67 | Domestic Hot Water 1 | Domestic Hot Water | 45912.8 | 0.0492126 | 557 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 974.3 | 0.0416667 | 5284
1083180 | Level 2 | Piping System: Domestic Hot Water 1 | 3114.67 | Domestic Hot Water 1 | Domestic Hot Water | 13580.8 | 0.0492126 | 615 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 288.193 | 0.0416667 | 5286
1083359 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 3672.28 | 0.0492126 | 614 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 77.9282 | 0.0416667 | 5291
1083529 | Level 2 | Piping System: Domestic Hot Water 1 | 3114.67 | Domestic Hot Water 1 | Domestic Hot Water | 2148.46 | 0.0492126 | 567 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 45.5918 | 0.0416667 | 5295
1084012 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 5670.63 | 0.0492126 | 550 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 120.334 | 0.0416667 | 5309
1084405 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 12719.3 | 0.0492126 | 654 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 269.912 | 0.0416667 | 5319
1084522 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 8027.91 | 0.0492126 | 655 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 170.358 | 0.0416667 | 5324
1084860 | Level 2 | Piping System: Domestic Hot Water 1 | 4764.67 | Domestic Hot Water 1 | Domestic Hot Water | 7524.7 | 0.0492126 | 498 | 200 | 0 | 200 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 159.679 | 0.0416667 | 5330
1084991 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 65130.9 | 0.0656168 | 502 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1036.59 | 0.0625 | 5331
1085021 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 1319.64 | 0.0492126 | 625 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 28.0036 | 0.0416667 | 5333
1085125 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 83258.3 | 0.0656168 | 496 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1325.1 | 0.0625 | 5337
1085219 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 2239.99 | 0.0492126 | 628 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 47.534 | 0.0416667 | 5342
1098080 | Level 1 | Piping System: Domestic Hot Water 1 | 350.195 | Domestic Hot Water 1 | Domestic Hot Water | 2295.06 | 0.0492126 | 9 | 355.525 | 0 | 355.525 | Level: Level 1 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 140.663 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 48.7028 | 0.0416667 | 5403
1098082 | Level 1 | Piping System: Domestic Hot Water 1 | 214.287 | Domestic Hot Water 1 | Domestic Hot Water | 5982.38 | 0.0492126 | 9 | 214.287 |  | 341.238 | Level: Level 1 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 366.656 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 126.95 | 0.0416667 | 5404
1098271 | Level 1 | Piping System: Domestic Hot Water 1 | 350.195 | Domestic Hot Water 1 | Domestic Hot Water | 2941.45 | 0.0492126 | 15 | 355.525 | 0 | 355.525 | Level: Level 1 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 180.28 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 62.4196 | 0.0416667 | 5408
1098272 | Level 1 | Piping System: Domestic Hot Water 1 | 350.195 | Domestic Hot Water 1 | Domestic Hot Water | 7419.7 | 0.0492126 | 15 | 355.525 | 0 | 355.525 | Level: Level 1 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 454.749 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 157.451 | 0.0416667 | 5409
1098508 | Level 1 | Piping System: Domestic Hot Water 1 | 350.195 | Domestic Hot Water 1 | Domestic Hot Water | 1998.69 | 0.0492126 | 18 | 355.525 | 0 | 355.525 | Level: Level 1 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 122.499 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 42.4136 | 0.0416667 | 5419
1098510 | Level 1 | Piping System: Domestic Hot Water 1 | 214.287 | Domestic Hot Water 1 | Domestic Hot Water | 5982.38 | 0.0492126 | 18 | 214.288 |  | 341.238 | Level: Level 1 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 366.656 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 126.95 | 0.0416667 | 5420
1098768 | Level 2 | Piping System: Domestic Hot Water 1 | 4920.2 | Domestic Hot Water 1 | Domestic Hot Water | 2482.93 | 0.0492126 | 22 | 355.525 | 0 | 355.525 | Level: Level 2 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 152.177 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 52.6894 | 0.0416667 | 5425
1098770 | Level 2 | Piping System: Domestic Hot Water 1 | 4784.29 | Domestic Hot Water 1 | Domestic Hot Water | 5982.38 | 0.0492126 | 22 | 214.287 |  | 341.238 | Level: Level 2 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 366.656 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 126.95 | 0.0416667 | 5426
1099071 | Level 2 | Piping System: Domestic Hot Water 1 | 4920.2 | Domestic Hot Water 1 | Domestic Hot Water | 2675.55 | 0.0492126 | 26 | 355.525 | 0 | 355.525 | Level: Level 2 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 163.983 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 56.777 | 0.0416667 | 5432
1099073 | Level 2 | Piping System: Domestic Hot Water 1 | 4784.29 | Domestic Hot Water 1 | Domestic Hot Water | 5982.38 | 0.0492126 | 26 | 214.287 |  | 341.238 | Level: Level 2 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 366.656 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 126.95 | 0.0416667 | 5433
1099366 | Level 1 | Piping System: Domestic Hot Water 1 | 350.195 | Domestic Hot Water 1 | Domestic Hot Water | 1447.29 | 0.0492126 | 30 | 355.525 | 0 | 355.525 | Level: Level 1 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 88.7037 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 30.7125 | 0.0416667 | 5437
1099367 | Level 1 | Piping System: Domestic Hot Water 1 | 350.195 | Domestic Hot Water 1 | Domestic Hot Water | 4470.28 | 0.0492126 | 30 | 355.525 | 0 | 355.525 | Level: Level 1 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 273.981 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 94.8624 | 0.0416667 | 5438
1118168 | Level 2 | Piping System: Domestic Hot Water 1 | 3155.76 | Domestic Hot Water 1 | Domestic Hot Water | 26230.7 | 0.104987 | 632 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 260.921 | 0.104167 | 5467
1118175 | Level 2 | Piping System: Domestic Hot Water 1 | 3155.76 | Domestic Hot Water 1 | Domestic Hot Water | 133692 | 0.104987 | 636 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 1329.86 | 0.104167 | 5468
1122928 | Level 2 | Piping System: Domestic Hot Water 1 | 3084.29 | Domestic Hot Water 1 | Domestic Hot Water | 5722.02 | 0.0492126 | 646 | -1364.29 |  | -1485.71 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 121.425 | 0.0416667 | 5477
1122937 | Level 2 | Piping System: Domestic Hot Water 1 | 3084.29 | Domestic Hot Water 1 | Domestic Hot Water | 5722.02 | 0.0492126 | 646 | -1485.71 |  | -1364.29 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 121.425 | 0.0416667 | 5478
1123084 | Level 2 | Piping System: Domestic Hot Water 1 | 3103.34 | Domestic Hot Water 1 | Domestic Hot Water | 5234.68 | 0.164042 | 653 | -1433.34 |  | -1466.66 | Level: Level 2 | 0 | 0 | 0 | 18716.5 | 0 | 0 | 0 | 0 | 0 | 0.155971 | 50 mmø | 33.325 | 0.166667 | 5479
1123092 | Level 2 | Piping System: Domestic Hot Water 1 | 3096.99 | Domestic Hot Water 1 | Domestic Hot Water | 2013.76 | 0.131234 | 447 | -1473.01 |  | -1456.99 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 16.025 | 0.125 | 5480
1123490 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 379929 | 0.0656168 | 651 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 6046.76 | 0.0625 | 5483
1123638 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 43171.3 | 0.0656168 | 651 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 687.093 | 0.0625 | 5484
1123643 | Level 2 | Piping System: Domestic Hot Water 1 | 3187.46 | Domestic Hot Water 1 | Domestic Hot Water | 947.19 | 0.0656168 | 651 | -1367.46 |  | -1382.54 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 15.075 | 0.0625 | 5485
1123649 | Level 2 | Piping System: Domestic Hot Water 1 | 3187.46 | Domestic Hot Water 1 | Domestic Hot Water | 947.19 | 0.0656168 | 651 | -1367.46 |  | -1382.54 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 15.075 | 0.0625 | 5486
1123932 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 64075.7 | 0.0656168 | 551 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1019.8 | 0.0625 | 5487
1123945 | Level 2 | Piping System: Domestic Hot Water 1 | 3214.67 | Domestic Hot Water 1 | Domestic Hot Water | 18176.3 | 0.0492126 | 562 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 385.713 | 0.0416667 | 5488
1124084 | Level 2 | Piping System: Domestic Hot Water 1 | 3061.9 | Domestic Hot Water 1 | Domestic Hot Water | 46963.9 | 0.0656168 | 551 | -1500 | 0 | -1500 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 747.454 | 0.0625 | 5489
1124091 | Level 2 | Piping System: Domestic Hot Water 1 | 3087.46 | Domestic Hot Water 1 | Domestic Hot Water | 4088.78 | 0.0656168 | 551 | -1417.46 |  | -1482.54 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 65.075 | 0.0625 | 5490
1124097 | Level 2 | Piping System: Domestic Hot Water 1 | 3087.46 | Domestic Hot Water 1 | Domestic Hot Water | 947.19 | 0.0656168 | 551 | -1467.46 |  | -1482.54 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 15.075 | 0.0625 | 5491
1124109 | Level 2 | Piping System: Domestic Hot Water 1 | 3064.67 | Domestic Hot Water 1 | Domestic Hot Water | 35522.2 | 0.0492126 | 562 | -1500 | 0 | -1500 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 753.804 | 0.0416667 | 5492
1124114 | Level 2 | Piping System: Domestic Hot Water 1 | 3084.29 | Domestic Hot Water 1 | Domestic Hot Water | 5722.02 | 0.0492126 | 562 | -1364.29 |  | -1485.71 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 121.425 | 0.0416667 | 5493
1124120 | Level 2 | Piping System: Domestic Hot Water 1 | 3084.29 | Domestic Hot Water 1 | Domestic Hot Water | 5722.02 | 0.0492126 | 562 | -1364.29 |  | -1485.71 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 121.425 | 0.0416667 | 5494
1124214 | Level 2 | Piping System: Domestic Hot Water 1 | 3111.9 | Domestic Hot Water 1 | Domestic Hot Water | 31734.8 | 0.0656168 | 640 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 505.075 | 0.0625 | 5495
1124225 | Level 2 | Piping System: Domestic Hot Water 1 | 3137.46 | Domestic Hot Water 1 | Domestic Hot Water | 4088.78 | 0.0656168 | 640 | -1367.46 |  | -1432.54 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 65.075 | 0.0625 | 5496
1124258 | Level 2 | Piping System: Domestic Hot Water 1 | 3143.02 | Domestic Hot Water 1 | Domestic Hot Water | 2954.37 | 0.0492126 | 646 | -1426.98 |  | -1364.29 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 62.6938 | 0.0416667 | 5497
1124350 | Level 2 | Piping System: Domestic Hot Water 1 | 3128.72 | Domestic Hot Water 1 | Domestic Hot Water | 28244.8 | 0.082021 | 433 | -1430 | 0 | -1430 | Level: Level 2 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 359.624 | 0.0833333 | 5500
1124355 | Level 2 | Piping System: Domestic Hot Water 1 | 3138.07 | Domestic Hot Water 1 | Domestic Hot Water | 1989.39 | 0.082021 | 433 | -1406.04 | 1 | -1423.96 | Level: Level 2 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 25.3297 | 0.0833333 | 5501
1124457 | Level 2 | Piping System: Domestic Cold Water 1 | 3064.67 | Domestic Cold Water 1 | Domestic Cold Water | 7244.02 | 0.0492126 | 755 | -1500 | 0 | -1500 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 153.723 | 0.0416667 | 5503
1124594 | Level 2 | Piping System: Domestic Hot Water 1 | 3152.58 | Domestic Hot Water 1 | Domestic Hot Water | 5783.67 | 0.131234 | 459 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 46.025 | 0.125 | 5504
1124615 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 185902 | 0.0656168 | 644 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 2958.73 | 0.0625 | 5505
1124661 | Level 2 | Piping System: Domestic Hot Water 1 | 3146.23 | Domestic Hot Water 1 | Domestic Hot Water | 483272 | 0.164042 | 653 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 18716.5 | 0 | 0 | 0 | 0 | 0 | 0.155971 | 50 mmø | 3076.6 | 0.166667 | 5506
1124683 | Level 2 | Piping System: Domestic Hot Water 1 | 3152.58 | Domestic Hot Water 1 | Domestic Hot Water | 86497.6 | 0.131234 | 459 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 688.326 | 0.125 | 5507
1124741 | Level 2 | Piping System: Domestic Hot Water 1 | 3214.67 | Domestic Hot Water 1 | Domestic Hot Water | 44154.6 | 0.0492126 | 453 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 936.989 | 0.0416667 | 5508
1124777 | Level 2 | Piping System: Domestic Hot Water 1 | 3214.67 | Domestic Hot Water 1 | Domestic Hot Water | 7432.26 | 0.0492126 | 646 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 157.717 | 0.0416667 | 5509
1124782 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 18475.7 | 0.0656168 | 644 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 294.049 | 0.0625 | 5510
1124833 | Level 2 | Piping System: Domestic Hot Water 1 | 3214.67 | Domestic Hot Water 1 | Domestic Hot Water | 173745 | 0.0492126 | 646 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 3686.99 | 0.0416667 | 5511
1124842 | Level 2 | Piping System: Domestic Hot Water 1 | 3146.23 | Domestic Hot Water 1 | Domestic Hot Water | 70535.4 | 0.164042 | 641 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 18716.5 | 0 | 0 | 0 | 0 | 0 | 0.155971 | 50 mmø | 449.042 | 0.166667 | 5512
1124915 | Level 2 | Piping System: Domestic Hot Water 1 | 3114.67 | Domestic Hot Water 1 | Domestic Hot Water | 27714.9 | 0.0492126 | 646 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 588.127 | 0.0416667 | 5513
1124922 | Level 2 | Piping System: Domestic Hot Water 1 | 3134.29 | Domestic Hot Water 1 | Domestic Hot Water | 3365.82 | 0.0492126 | 646 | -1364.29 |  | -1435.71 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 71.425 | 0.0416667 | 5514
1124928 | Level 2 | Piping System: Domestic Hot Water 1 | 3134.29 | Domestic Hot Water 1 | Domestic Hot Water | 3365.82 | 0.0492126 | 646 | -1364.29 |  | -1435.71 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 71.425 | 0.0416667 | 5515
1124936 | Level 2 | Piping System: Domestic Hot Water 1 | 3096.23 | Domestic Hot Water 1 | Domestic Hot Water | 73672.2 | 0.164042 | 641 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 18716.5 | 0 | 0 | 0 | 0 | 0 | 0.155971 | 50 mmø | 469.011 | 0.166667 | 5516
1124942 | Level 2 | Piping System: Domestic Hot Water 1 | 3112.96 | Domestic Hot Water 1 | Domestic Hot Water | 6769.03 | 0.164042 | 641 | -1409.76 | 1 | -1440.24 | Level: Level 2 | 0 | 0 | 0 | 18716.5 | 0 | 0 | 0 | 0 | 0 | 0.155971 | 50 mmø | 43.093 | 0.166667 | 5517
1124949 | Level 2 | Piping System: Domestic Hot Water 1 | 3112.96 | Domestic Hot Water 1 | Domestic Hot Water | 6769.03 | 0.164042 | 641 | -1409.76 | 1 | -1440.24 | Level: Level 2 | 0 | 0 | 0 | 18716.5 | 0 | 0 | 0 | 0 | 0 | 0.155971 | 50 mmø | 43.093 | 0.166667 | 5518
1124980 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 101178 | 0.0656168 | 651 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1610.3 | 0.0625 | 5519
1124985 | Level 2 | Piping System: Domestic Hot Water 1 | 3155.76 | Domestic Hot Water 1 | Domestic Hot Water | 5648.58 | 0.104987 | 514 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 56.1875 | 0.104167 | 5520
1125089 | Level 2 | Piping System: Domestic Hot Water 1 | 3111.9 | Domestic Hot Water 1 | Domestic Hot Water | 43707.3 | 0.0656168 | 651 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 695.623 | 0.0625 | 5521
1125094 | Level 2 | Piping System: Domestic Hot Water 1 | 3137.46 | Domestic Hot Water 1 | Domestic Hot Water | 4088.78 | 0.0656168 | 651 | -1367.46 |  | -1432.54 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 65.075 | 0.0625 | 5522
1125100 | Level 2 | Piping System: Domestic Hot Water 1 | 3137.46 | Domestic Hot Water 1 | Domestic Hot Water | 4088.78 | 0.0656168 | 651 | -1367.46 |  | -1432.54 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 65.075 | 0.0625 | 5523
1125125 | Level 2 | Piping System: Domestic Hot Water 1 | 3075.76 | Domestic Hot Water 1 | Domestic Hot Water | 64959.2 | 0.104987 | 514 | -1480 | 0 | -1480 | Level: Level 2 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 646.161 | 0.104167 | 5524
1125130 | Level 2 | Piping System: Domestic Hot Water 1 | 3113.81 | Domestic Hot Water 1 | Domestic Hot Water | 3254.69 | 0.104987 | 514 | -1423.81 |  | -1456.19 | Level: Level 2 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 32.375 | 0.104167 | 5525
1125136 | Level 2 | Piping System: Domestic Hot Water 1 | 3113.81 | Domestic Hot Water 1 | Domestic Hot Water | 3254.69 | 0.104987 | 514 | -1423.81 |  | -1456.19 | Level: Level 2 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 32.375 | 0.104167 | 5526
1125189 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 348190 | 0.0656168 | 484 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 5541.61 | 0.0625 | 5527
1125253 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 424909 | 0.0656168 | 647 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 6762.64 | 0.0625 | 5528
1125265 | Level 2 | Piping System: Domestic Hot Water 1 | 3111.9 | Domestic Hot Water 1 | Domestic Hot Water | 25714.9 | 0.0656168 | 484 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 409.266 | 0.0625 | 5529
1125272 | Level 2 | Piping System: Domestic Hot Water 1 | 3137.46 | Domestic Hot Water 1 | Domestic Hot Water | 4088.78 | 0.0656168 | 484 | -1367.46 |  | -1432.54 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 65.075 | 0.0625 | 5530
1125278 | Level 2 | Piping System: Domestic Hot Water 1 | 3137.46 | Domestic Hot Water 1 | Domestic Hot Water | 4088.78 | 0.0656168 | 484 | -1367.46 |  | -1432.54 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 65.075 | 0.0625 | 5531
1125667 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 98177.1 | 0.0656168 | 648 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1562.54 | 0.0625 | 5532
1125693 | Level 2 | Piping System: Domestic Hot Water 1 | 3152.58 | Domestic Hot Water 1 | Domestic Hot Water | 231009 | 0.131234 | 456 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 1838.31 | 0.125 | 5533
1125824 | Level 2 | Piping System: Domestic Hot Water 1 | 3102.58 | Domestic Hot Water 1 | Domestic Hot Water | 31098.8 | 0.131234 | 456 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 247.476 | 0.125 | 5534
1125832 | Level 2 | Piping System: Domestic Hot Water 1 | 3115.59 | Domestic Hot Water 1 | Domestic Hot Water | 6076.28 | 0.131234 | 456 | -1407.9 | 1 | -1442.1 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 48.3535 | 0.125 | 5535
1125838 | Level 2 | Piping System: Domestic Hot Water 1 | 3115.59 | Domestic Hot Water 1 | Domestic Hot Water | 6076.28 | 0.131234 | 456 | -1407.9 | 1 | -1442.1 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 48.3535 | 0.125 | 5536
1125850 | Level 2 | Piping System: Domestic Hot Water 1 | 3111.9 | Domestic Hot Water 1 | Domestic Hot Water | 21042.9 | 0.0656168 | 648 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 334.909 | 0.0625 | 5537
1125857 | Level 2 | Piping System: Domestic Hot Water 1 | 3137.46 | Domestic Hot Water 1 | Domestic Hot Water | 4088.78 | 0.0656168 | 648 | -1367.46 |  | -1432.54 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 65.075 | 0.0625 | 5538
1125863 | Level 2 | Piping System: Domestic Hot Water 1 | 3137.46 | Domestic Hot Water 1 | Domestic Hot Water | 4088.78 | 0.0656168 | 648 | -1367.46 |  | -1432.54 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 65.075 | 0.0625 | 5539
1125904 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 14985.9 | 0.0656168 | 650 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 238.508 | 0.0625 | 5540
1125909 | Level 2 | Piping System: Domestic Hot Water 1 | 3214.67 | Domestic Hot Water 1 | Domestic Hot Water | 391442 | 0.0492126 | 556 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 8306.66 | 0.0416667 | 5541
1125960 | Level 2 | Piping System: Domestic Hot Water 1 | 3111.9 | Domestic Hot Water 1 | Domestic Hot Water | 20420.4 | 0.0656168 | 650 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 325 | 0.0625 | 5542
1125965 | Level 2 | Piping System: Domestic Hot Water 1 | 3137.46 | Domestic Hot Water 1 | Domestic Hot Water | 947.19 | 0.0656168 | 650 | -1417.46 |  | -1432.54 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 15.075 | 0.0625 | 5543
1125971 | Level 2 | Piping System: Domestic Hot Water 1 | 3137.46 | Domestic Hot Water 1 | Domestic Hot Water | 947.19 | 0.0656168 | 650 | -1417.46 |  | -1432.54 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 15.075 | 0.0625 | 5544
1125983 | Level 2 | Piping System: Domestic Hot Water 1 | 3114.67 | Domestic Hot Water 1 | Domestic Hot Water | 16533.9 | 0.0492126 | 556 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 350.861 | 0.0416667 | 5545
1125988 | Level 2 | Piping System: Domestic Hot Water 1 | 3134.29 | Domestic Hot Water 1 | Domestic Hot Water | 3365.82 | 0.0492126 | 556 | -1364.29 |  | -1435.71 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 71.425 | 0.0416667 | 5546
1125994 | Level 2 | Piping System: Domestic Hot Water 1 | 3134.29 | Domestic Hot Water 1 | Domestic Hot Water | 3365.82 | 0.0492126 | 556 | -1364.29 |  | -1435.71 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 71.425 | 0.0416667 | 5547
1126023 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 32260.2 | 0.0492126 | 555 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 684.583 | 0.0416667 | 5548
1126063 | Level 2 | Piping System: Domestic Hot Water 1 | 3114.67 | Domestic Hot Water 1 | Domestic Hot Water | 14383.2 | 0.0492126 | 555 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 305.221 | 0.0416667 | 5549
1126068 | Level 2 | Piping System: Domestic Hot Water 1 | 3134.29 | Domestic Hot Water 1 | Domestic Hot Water | 1009.63 | 0.0492126 | 555 | -1414.29 |  | -1435.71 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 21.425 | 0.0416667 | 5550
1126074 | Level 2 | Piping System: Domestic Hot Water 1 | 3134.29 | Domestic Hot Water 1 | Domestic Hot Water | 1009.63 | 0.0492126 | 555 | -1414.29 |  | -1435.71 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 21.425 | 0.0416667 | 5551
1126103 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 192960 | 0.0656168 | 647 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 3071.05 | 0.0625 | 5552
1126108 | Level 2 | Piping System: Domestic Hot Water 1 | 3158.72 | Domestic Hot Water 1 | Domestic Hot Water | 140382 | 0.082021 | 504 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 1787.4 | 0.0833333 | 5553
1126244 | Level 2 | Piping System: Domestic Hot Water 1 | 3058.72 | Domestic Hot Water 1 | Domestic Hot Water | 40834.7 | 0.082021 | 504 | -1500 | 0 | -1500 | Level: Level 2 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 519.923 | 0.0833333 | 5554
1126249 | Level 2 | Piping System: Domestic Hot Water 1 | 3090.64 | Domestic Hot Water 1 | Domestic Hot Water | 4612.25 | 0.082021 | 504 | -1420.64 |  | -1479.36 | Level: Level 2 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 58.725 | 0.0833333 | 5555
1126255 | Level 2 | Piping System: Domestic Hot Water 1 | 3090.64 | Domestic Hot Water 1 | Domestic Hot Water | 4612.25 | 0.082021 | 504 | -1420.64 |  | -1479.36 | Level: Level 2 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 58.725 | 0.0833333 | 5556
1126296 | Level 2 | Piping System: Domestic Hot Water 1 | 3061.9 | Domestic Hot Water 1 | Domestic Hot Water | 35313.2 | 0.0656168 | 647 | -1500 | 0 | -1500 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 562.027 | 0.0625 | 5557
1126301 | Level 2 | Piping System: Domestic Hot Water 1 | 3087.46 | Domestic Hot Water 1 | Domestic Hot Water | 7230.38 | 0.0656168 | 647 | -1367.46 |  | -1482.54 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 115.075 | 0.0625 | 5558
1126307 | Level 2 | Piping System: Domestic Hot Water 1 | 3087.46 | Domestic Hot Water 1 | Domestic Hot Water | 7230.38 | 0.0656168 | 647 | -1367.46 |  | -1482.54 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 115.075 | 0.0625 | 5559
1126378 | Level 2 | Piping System: Domestic Hot Water 1 | 3052.58 | Domestic Hot Water 1 | Domestic Hot Water | 577978 | 0.131234 | 452 | -1500 | 0 | -1500 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 4599.4 | 0.125 | 5560
1126399 | Level 2 | Piping System: Domestic Hot Water 1 | 3064.67 | Domestic Hot Water 1 | Domestic Hot Water | 1029724 | 0.0492126 | 646 | -1500 | 0 | -1500 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 21851.4 | 0.0416667 | 5561
1126531 | Level 2 | Piping System: Domestic Hot Water 1 | 3002.58 | Domestic Hot Water 1 | Domestic Hot Water | 41100.1 | 0.131234 | 452 | -1550 | 0 | -1550 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 327.064 | 0.125 | 5562
1126540 | Level 2 | Piping System: Domestic Hot Water 1 | 3015.59 | Domestic Hot Water 1 | Domestic Hot Water | 6076.28 | 0.131234 | 452 | -1507.9 | 1 | -1542.1 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 48.3535 | 0.125 | 5563
1126546 | Level 2 | Piping System: Domestic Hot Water 1 | 3015.59 | Domestic Hot Water 1 | Domestic Hot Water | 6076.28 | 0.131234 | 452 | -1507.9 | 1 | -1542.1 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 48.3535 | 0.125 | 5564
1126558 | Level 2 | Piping System: Domestic Hot Water 1 | 3014.67 | Domestic Hot Water 1 | Domestic Hot Water | 20521.4 | 0.0492126 | 646 | -1550 | 0 | -1550 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 435.477 | 0.0416667 | 5565
1126565 | Level 2 | Piping System: Domestic Hot Water 1 | 3034.29 | Domestic Hot Water 1 | Domestic Hot Water | 1009.63 | 0.0492126 | 646 | -1514.29 |  | -1535.71 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 21.425 | 0.0416667 | 5566
1126571 | Level 2 | Piping System: Domestic Hot Water 1 | 3034.29 | Domestic Hot Water 1 | Domestic Hot Water | 1009.63 | 0.0492126 | 646 | -1514.29 |  | -1535.71 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 21.425 | 0.0416667 | 5567
1126651 | Level 2 | Piping System: Domestic Hot Water 1 | 3111.9 | Domestic Hot Water 1 | Domestic Hot Water | 20757.3 | 0.0656168 | 679 | -1450 | 0 | -1450 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 330.362 | 0.0625 | 5568
1126658 | Level 2 | Piping System: Domestic Hot Water 1 | 3137.46 | Domestic Hot Water 1 | Domestic Hot Water | 947.19 | 0.0656168 | 679 | -1417.46 |  | -1432.54 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 15.075 | 0.0625 | 5569
1126668 | Level 2 | Piping System: Domestic Hot Water 1 | 3137.46 | Domestic Hot Water 1 | Domestic Hot Water | 947.19 | 0.0656168 | 679 | -1432.54 |  | -1417.46 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 15.075 | 0.0625 | 5570
1128156 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 39180 | 0.0492126 | 479 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 831.425 | 0.0416667 | 5594
1128229 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 774.01 | 0.0492126 | 479 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 16.425 | 0.0416667 | 5595
1128236 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 14911.2 | 0.0492126 | 479 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 316.425 | 0.0416667 | 5596
1128241 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 774.01 | 0.0492126 | 479 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 16.425 | 0.0416667 | 5597
1128513 | Level 2 | Piping System: Domestic Hot Water 1 | 3152.58 | Domestic Hot Water 1 | Domestic Hot Water | 292383 | 0.131234 | 459 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 2326.71 | 0.125 | 5598
1128600 | Level 2 | Piping System: Domestic Hot Water 1 | 3052.58 | Domestic Hot Water 1 | Domestic Hot Water | 68366.2 | 0.131234 | 459 | -1500 | 0 | -1500 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 544.041 | 0.125 | 5599
1128606 | Level 2 | Piping System: Domestic Hot Water 1 | 3096.99 | Domestic Hot Water 1 | Domestic Hot Water | 5783.67 | 0.131234 | 459 | -1426.99 |  | -1473.01 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 46.025 | 0.125 | 5600
1128612 | Level 2 | Piping System: Domestic Hot Water 1 | 3096.99 | Domestic Hot Water 1 | Domestic Hot Water | 5783.67 | 0.131234 | 459 | -1426.99 |  | -1473.01 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 46.025 | 0.125 | 5601
1129045 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 41560.5 | 0.0492126 | 654 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 881.94 | 0.0416667 | 5602
1129226 | Level 2 | Piping System: Domestic Hot Water 1 | 3064.67 | Domestic Hot Water 1 | Domestic Hot Water | 46142.1 | 0.0492126 | 654 | -1500 | 0 | -1500 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 979.166 | 0.0416667 | 5603
1129231 | Level 2 | Piping System: Domestic Hot Water 1 | 3084.29 | Domestic Hot Water 1 | Domestic Hot Water | 3365.82 | 0.0492126 | 654 | -1414.29 |  | -1485.71 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 71.425 | 0.0416667 | 5604
1129237 | Level 2 | Piping System: Domestic Hot Water 1 | 3084.29 | Domestic Hot Water 1 | Domestic Hot Water | 3365.82 | 0.0492126 | 654 | -1414.29 |  | -1485.71 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 71.425 | 0.0416667 | 5605
1185052 | TOF Footing | Piping System: Domestic Hot Water 1 | 214.284 | Domestic Hot Water 1 | Domestic Hot Water | 27875.9 | 0.0492126 | 246 | 1805.83 | 1506.24 | 1214.29 | Level: TOF Footing | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 591.545 | 0.0416667 | 5643
1191289 | Level 1 | Piping System: Domestic Cold Water 1 | 690.543 | Domestic Cold Water 1 | Domestic Cold Water | 5073.99 | 0.0492126 | 90 | 690.55 | 815.611 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 107.673 | 0.0416667 | 5646
1201098 | Level 2 | Piping System: Domestic Hot Water 1 | 5181.24 | Domestic Hot Water 1 | Domestic Hot Water | 3547.73 | 0.0492126 | 688 | 616.57 | 0 | 616.57 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 75.2851 | 0.0416667 | 5675
1201150 | Level 2 | Piping System: Domestic Hot Water 1 | 4884.29 | Domestic Hot Water 1 | Domestic Hot Water | 13571.5 | 0.0492126 | 688 | 602.283 |  | 314.288 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 287.995 | 0.0416667 | 5676
1203509 | Level 2 | Piping System: Domestic Hot Water 1 | 3164.67 | Domestic Hot Water 1 | Domestic Hot Water | 75225.9 | 0.0492126 | 691 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1596.34 | 0.0416667 | 5685
1204536 | Level 1 | Piping System: Domestic Hot Water 1 | 1060.67 | Domestic Hot Water 1 | Domestic Hot Water | 4779.54 | 0.0492126 | 74 | 1066 | 0 | 1066 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 101.425 | 0.0416667 | 5692
1204564 | Level 1 | Piping System: Domestic Hot Water 1 | 900.112 | Domestic Hot Water 1 | Domestic Hot Water | 7143.98 | 0.0492126 | 74 | 900.113 |  | 1051.71 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 151.6 | 0.0416667 | 5693
1204860 | Level 1 | Piping System: Domestic Hot Water 1 | 1060.67 | Domestic Hot Water 1 | Domestic Hot Water | 2842.75 | 0.0492126 | 74 | 1066 | 0 | 1066 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 60.325 | 0.0416667 | 5694
1204875 | Level 1 | Piping System: Domestic Hot Water 1 | 1060.67 | Domestic Hot Water 1 | Domestic Hot Water | 1267.09 | 0.0492126 | 74 | 1066 | 0 | 1066 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 26.8885 | 0.0416667 | 5695

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1066972 (48)
Type - ElementType: Pipe Types:Mechanical Pipe:1066972
Text - LeakageCurve: 0; FluidFlowLeakage: 0; InteriorRoughnessCoefficient: 0; PressureRange: 0; TemperatureRange: 0; WorkingPressure: 0; InnerDiameter: 1; Gradient: 0; OuterDiameter: 1; NominalDiameter: 1; InvertElevation: 1
Other - Constituents: N/A; Color: White; Features: N/A; NominalHeight: 0; ReplacementCost: N/A; AssetAccountingType: FIXED; NominalLength: 0; AccessibilityPerformance: N/A; Classification Code: 23-60 30 11 11; Reference: Type A - 1; NominalWidth: 0; Grade: N/A; WarrantyGuarantorParts: N/A; ModelLabel: N/A; WarrantyGuarantorLabor: N/A; WarrantyDescription: N/A; CodePerformance: N/A; ModelReference: N/A; Classification Description: Pipes for General Use; Shape: N/A; SustainabilityPerformance: N/A; WarrantyDurationLabor: N/A; ExpectedLife: N/A; ProductionYear: N/A; WarrantyDurationParts: N/A; SerialNumber: N/A; BarCode: N/A; InstallationDate: N/A; WarrantyStartDate: N/A; TagNumber: N/A; AssetIdentifier: N/A
Identity Data - Manufacturer: N/A
Mechanical - Connection Type: Generic; Material: Carbon Steel; Schedule/Type: Pipe Schedule Types: Schedule 40; Pipe Segment: Carbon Steel - Schedule 40; Roughness: 0.00015
Mechanical - Flow - Friction: 0; Pressure Drop: 0; Flow State: 0; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Friction Factor: 0; Velocity: 0
Constraints - Vertical Justification: 0; Horizontal Justification: 0
Phasing - Phase Created: New Construction
Name (Pipe Types:Mechanical Pipe:...) | In | System Name | Diameter | Invert Elevation (mm) | System Classification | Area (mm2) | Section | System Type | Relative Roughness | Reference Level | Start Offset (mm) = Offset (mm) | Slope | End Offset (mm) | Inner Diameter | Length (mm) | Size = Overall Size | Outer Diameter | Mark
1066972 | Level 1 | Hydronic Return 1 | 0.492126 | -677.026 | Hydronic Return | 443594 | 3 | Piping System: Hydronic Return 1 | 3369.44 | Level: Level 1 | -600 | 0 | -600 | 0.505417 | 941.335 | 150 mmø | 0.552083 | 5023
1066978 | Level 1 | Hydronic Return 1 | 0.492126 | -677.026 | Hydronic Return | 1171466 | 3 | Piping System: Hydronic Return 1 | 3369.44 | Level: Level 1 | -600 | 0 | -600 | 0.505417 | 2485.93 | 150 mmø | 0.552083 | 5024
1067026 | Level 1 | Hydronic Return 1 | 0.492126 | -677.026 | Hydronic Return | 4397472 | 3 | Piping System: Hydronic Return 1 | 3369.44 | Level: Level 1 | -600 | 0 | -600 | 0.505417 | 9331.73 | 150 mmø | 0.552083 | 5025
1067037 | Level 1 | Hydronic Return 1 | 0.492126 | -677.026 | Hydronic Return | 4962958 | 3 | Piping System: Hydronic Return 1 | 3369.44 | Level: Level 1 | -600 | 0 | -600 | 0.505417 | 10531.7 | 150 mmø | 0.552083 | 5026
1067042 | Level 1 | Hydronic Return 1 | 0.492126 | -677.026 | Hydronic Return | 3454994 | 3 | Piping System: Hydronic Return 1 | 3369.44 | Level: Level 1 | -600 | 0 | -600 | 0.505417 | 7331.73 | 150 mmø | 0.552083 | 5027
1067082 | Level 2 | Hydronic Return 1 | 0.492126 | -515.863 | Hydronic Return | 1570038 | 3 | Piping System: Hydronic Return 1 | 3369.44 | Level: Level 2 | -5085.86 |  | -1754.14 | 0.505417 | 3331.73 | 150 mmø | 0.552083 | 5029
1067342 | Level 1 | Hydronic Return 1 | 0.492126 | 209.974 | Hydronic Return | 1863310 | 3 | Piping System: Hydronic Return 1 | 3369.44 | Level: Level 1 | 287 | 0 | 287 | 0.505417 | 3954.07 | 150 mmø | 0.552083 | 5030
1067464 | Level 1 | Hydronic Return 1 | 0.492126 | -515.863 | Hydronic Return | 338691 | 3 | Piping System: Hydronic Return 1 | 3369.44 | Level: Level 1 | 202.862 |  | -515.863 | 0.505417 | 718.725 | 150 mmø | 0.552083 | 5032
1067529 | Level 1 | Hydronic Supply 1 | 0.492126 | 493.974 | Hydronic Supply | 1873581 | 3 | Piping System: Hydronic Supply 1 | 3369.44 | Level: Level 1 | 571 | 0 | 571 | 0.505417 | 3975.86 | 150 mmø | 0.552083 | 5033
1067591 | Level 1 | Hydronic Supply 1 | 0.492126 | -515.863 | Hydronic Supply | 472523 | 3 | Piping System: Hydronic Supply 1 | 3369.44 | Level: Level 1 | 486.862 |  | -515.863 | 0.505417 | 1002.72 | 150 mmø | 0.552083 | 5036
1067595 | Level 1 | Hydronic Supply 1 | 0.492126 | -677.026 | Hydronic Supply | 335393 | 3 | Piping System: Hydronic Supply 1 | 3369.44 | Level: Level 1 | -600 | 0 | -600 | 0.505417 | 711.725 | 150 mmø | 0.552083 | 5037
1067834 | Level 1 | Hydronic Return 1 | 0.492126 | -677.026 | Hydronic Return | 533313 | 3 | Piping System: Hydronic Return 1 | 3369.44 | Level: Level 1 | -600 | 0 | -600 | 0.505417 | 1131.72 | 150 mmø | 0.552083 | 5038
1067841 | Level 1 | Hydronic Return 1 | 0.492126 | -677.026 | Hydronic Return | 135186 | 3 | Piping System: Hydronic Return 1 | 3369.44 | Level: Level 1 | -600 | 0 | -600 | 0.505417 | 286.874 | 150 mmø | 0.552083 | 5039
1067931 | Level 2 | Hydronic Return 1 | 0.492126 | 2822.97 | Hydronic Return | 181095 | 3 | Piping System: Hydronic Return 1 | 3369.44 | Level: Level 2 | -1670 | 0 | -1670 | 0.505417 | 384.295 | 150 mmø | 0.552083 | 5040
1067943 | Level 2 | Hydronic Return 1 | 0.492126 | 2822.97 | Hydronic Return | 486189 | 3 | Piping System: Hydronic Return 1 | 3369.44 | Level: Level 2 | -1670 | 0 | -1670 | 0.505417 | 1031.73 | 150 mmø | 0.552083 | 5041
1067948 | Level 2 | Hydronic Return 1 | 0.492126 | 2822.97 | Hydronic Return | 1193047 | 3 | Piping System: Hydronic Return 1 | 3369.44 | Level: Level 2 | -1670 | 0 | -1670 | 0.505417 | 2531.73 | 150 mmø | 0.552083 | 5042
1068026 | Level 2 | Hydronic Return 1 | 0.492126 | 2984.14 | Hydronic Return | 2592627 | 3 | Piping System: Hydronic Return 1 | 3369.44 | Level: Level 2 | -1585.86 |  | 3915.86 | 0.505417 | 5501.73 | 150 mmø | 0.552083 | 5044
1068030 | Level 2 | Hydronic Return 1 | 0.328084 | 8518.87 | Hydronic Return | 2918526 | 5 | Piping System: Hydronic Return 1 | 2236.67 | Level: Level 2 | 4000 | 0 | 4000 | 0.3355 | 9289.96 | 100 mmø | 0.375 | 5045
1068090 | Level 2 | Hydronic Return 1 | 0.328084 | 8518.87 | Hydronic Return | 180633 | 5 | Piping System: Hydronic Return 1 | 2236.67 | Level: Level 2 | 4000 | 0 | 4000 | 0.3355 | 574.973 | 100 mmø | 0.375 | 5046
1068207 | Level 2 | Hydronic Return 1 | 0.328084 | 8518.87 | Hydronic Return | 474405 | 1 | Piping System: Hydronic Return 1 | 2236.67 | Level: Level 2 | 4000 | 0 | 4000 | 0.3355 | 1510.08 | 100 mmø | 0.375 | 5051
1068250 | Level 2 | Hydronic Return 1 | 0.328084 | 4666.84 | Hydronic Return | 1207762 | 1 | Piping System: Hydronic Return 1 | 2236.67 | Level: Level 2 | 3941.26 |  | 96.8375 | 0.3355 | 3844.43 | 100 mmø | 0.375 | 5052
1068358 | Level 2 | Hydronic Return 1 | 0.492126 | 8492.97 | Hydronic Return | 1941261 | 3 | Piping System: Hydronic Return 1 | 3369.44 | Level: Level 2 | 4000 | 0 | 4000 | 0.505417 | 4119.48 | 150 mmø | 0.552083 | 5056
1068496 | Level 1 | Hydronic Supply 1 | 0.492126 | 493.974 | Hydronic Supply | 73587.2 | 3 | Piping System: Hydronic Supply 1 | 3369.44 | Level: Level 1 | 571 | 0 | 571 | 0.505417 | 156.157 | 150 mmø | 0.552083 | 5058
1068583 | Level 1 | Hydronic Supply 1 | 0.492126 | -677.026 | Hydronic Supply | 1145923 | 3 | Piping System: Hydronic Supply 1 | 3369.44 | Level: Level 1 | -600 | 0 | -600 | 0.505417 | 2431.72 | 150 mmø | 0.552083 | 5059
1068590 | Level 1 | Hydronic Supply 1 | 0.492126 | -677.026 | Hydronic Supply | 4416321 | 3 | Piping System: Hydronic Supply 1 | 3369.44 | Level: Level 1 | -600 | 0 | -600 | 0.505417 | 9371.73 | 150 mmø | 0.552083 | 5060
1068608 | Level 1 | Hydronic Supply 1 | 0.492126 | -677.026 | Hydronic Supply | 5036179 | 3 | Piping System: Hydronic Supply 1 | 3369.44 | Level: Level 1 | -600 | 0 | -600 | 0.505417 | 10687.1 | 150 mmø | 0.552083 | 5062
1068612 | Level 1 | Hydronic Supply 1 | 0.492126 | -677.026 | Hydronic Supply | 3454994 | 3 | Piping System: Hydronic Supply 1 | 3369.44 | Level: Level 1 | -600 | 0 | -600 | 0.505417 | 7331.73 | 150 mmø | 0.552083 | 5063
1068623 | Level 1 | Hydronic Supply 1 | 0.492126 | -677.026 | Hydronic Supply | 486189 | 3 | Piping System: Hydronic Supply 1 | 3369.44 | Level: Level 1 | -600 | 0 | -600 | 0.505417 | 1031.72 | 150 mmø | 0.552083 | 5064
1068628 | Level 1 | Hydronic Supply 1 | 0.492126 | -677.026 | Hydronic Supply | 222295 | 3 | Piping System: Hydronic Supply 1 | 3369.44 | Level: Level 1 | -600 | 0 | -600 | 0.505417 | 471.725 | 150 mmø | 0.552083 | 5065
1068654 | Level 2 | Hydronic Supply 1 | 0.492126 | 2822.97 | Hydronic Supply | 278844 | 3 | Piping System: Hydronic Supply 1 | 3369.44 | Level: Level 2 | -1670 | 0 | -1670 | 0.505417 | 591.725 | 150 mmø | 0.552083 | 5066
1068689 | Level 1 | Hydronic Supply 1 | 0.492126 | -515.863 | Hydronic Supply | 1570038 | 3 | Piping System: Hydronic Supply 1 | 3369.44 | Level: Level 1 | -515.863 |  | 2815.86 | 0.505417 | 3331.73 | 150 mmø | 0.552083 | 5067
1068757 | Level 2 | Hydronic Supply 1 | 0.492126 | 2822.97 | Hydronic Supply | 542738 | 3 | Piping System: Hydronic Supply 1 | 3369.44 | Level: Level 2 | -1670 | 0 | -1670 | 0.505417 | 1151.73 | 150 mmø | 0.552083 | 5068
1068764 | Level 2 | Hydronic Supply 1 | 0.492126 | 2822.97 | Hydronic Supply | 1193047 | 3 | Piping System: Hydronic Supply 1 | 3369.44 | Level: Level 2 | -1670 | 0 | -1670 | 0.505417 | 2531.73 | 150 mmø | 0.552083 | 5069
1068771 | Level 2 | Hydronic Supply 1 | 0.492126 | 2822.97 | Hydronic Supply | 14950.1 | 3 | Piping System: Hydronic Supply 1 | 3369.44 | Level: Level 2 | -1670 | 0 | -1670 | 0.505417 | 31.725 | 150 mmø | 0.552083 | 5070
1068776 | Level 2 | Hydronic Supply 1 | 0.492126 | 8292.97 | Hydronic Supply | 2038317 | 3 | Piping System: Hydronic Supply 1 | 3369.44 | Level: Level 2 | 3800 | 0 | 3800 | 0.505417 | 4325.44 | 150 mmø | 0.552083 | 5071
1068885 | Level 2 | Hydronic Supply 1 | 0.492126 | 2984.14 | Hydronic Supply | 2498379 | 3 | Piping System: Hydronic Supply 1 | 3369.44 | Level: Level 2 | -1585.86 |  | 3715.86 | 0.505417 | 5301.73 | 150 mmø | 0.552083 | 5072
1068890 | Level 2 | Hydronic Supply 1 | 0.328084 | 8318.87 | Hydronic Supply | 2907370 | 5 | Piping System: Hydronic Supply 1 | 2236.67 | Level: Level 2 | 3800 | 0 | 3800 | 0.3355 | 9254.45 | 100 mmø | 0.375 | 5073
1068907 | Level 2 | Hydronic Supply 1 | 0.328084 | 8318.87 | Hydronic Supply | 191400 | 5 | Piping System: Hydronic Supply 1 | 2236.67 | Level: Level 2 | 3800 | 0 | 3800 | 0.3355 | 609.244 | 100 mmø | 0.375 | 5074
1069022 | Level 2 | Hydronic Supply 1 | 0.328084 | 4666.84 | Hydronic Supply | 1144930 | 1 | Piping System: Hydronic Supply 1 | 2236.67 | Level: Level 2 | 96.8375 |  | 3741.26 | 0.3355 | 3644.43 | 100 mmø | 0.375 | 5080
1069027 | Level 2 | Hydronic Supply 1 | 0.328084 | 8318.87 | Hydronic Supply | 416105 | 1 | Piping System: Hydronic Supply 1 | 2236.67 | Level: Level 2 | 3800 | 0 | 3800 | 0.3355 | 1324.5 | 100 mmø | 0.375 | 5081
1070236 | Level 2 | Hydronic Return 1 | 0.328084 | 4556.97 | Hydronic Return | 34142.6 | 1 | Piping System: Hydronic Return 1 | 2236.67 | Level: Level 2 | 38.1 | 0 | 38.1 | 0.3355 | 108.679 | 100 mmø | 0.375 | 5083
1070245 | Level 2 | Hydronic Supply 1 | 0.328084 | 4556.97 | Hydronic Supply | 34142.6 | 1 | Piping System: Hydronic Supply 1 | 2236.67 | Level: Level 2 | 38.1 | 0 | 38.1 | 0.3355 | 108.679 | 100 mmø | 0.375 | 5084
1070306 | Level 2 | Hydronic Supply 1 | 0.328084 | 8318.87 | Hydronic Supply | 97959.2 | 5 | Piping System: Hydronic Supply 1 | 2236.67 | Level: Level 2 | 3800 | 0 | 3800 | 0.3355 | 311.814 | 100 mmø | 0.375 | 5086
1070333 | Level 2 | Hydronic Return 1 | 0.328084 | 8518.87 | Hydronic Return | 87192.5 | 5 | Piping System: Hydronic Return 1 | 2236.67 | Level: Level 2 | 4000 | 0 | 4000 | 0.3355 | 277.542 | 100 mmø | 0.375 | 5088
1070408 | Level 2 | Hydronic Return 1 | 0.328084 | 4556.97 | Hydronic Return | 89888.3 | 5 | Piping System: Hydronic Return 1 | 2236.67 | Level: Level 2 | 38.1 | 0 | 38.1 | 0.3355 | 286.123 | 100 mmø | 0.375 | 5089
1070435 | Level 2 | Hydronic Supply 1 | 0.328084 | 4556.97 | Hydronic Supply | 42744.3 | 5 | Piping System: Hydronic Supply 1 | 2236.67 | Level: Level 2 | 38.1 | 0 | 38.1 | 0.3355 | 136.059 | 100 mmø | 0.375 | 5090
1070443 | Level 2 | Hydronic Supply 1 | 0.328084 | 4666.84 | Hydronic Supply | 1144930 | 5 | Piping System: Hydronic Supply 1 | 2236.67 | Level: Level 2 | 3741.26 |  | 96.8375 | 0.3355 | 3644.43 | 100 mmø | 0.375 | 5091
1070460 | Level 2 | Hydronic Return 1 | 0.328084 | 4666.84 | Hydronic Return | 1207762 | 5 | Piping System: Hydronic Return 1 | 2236.67 | Level: Level 2 | 96.8375 |  | 3941.26 | 0.3355 | 3844.43 | 100 mmø | 0.375 | 5092

# IfcFlowSegment: Pipe Types:Storm:721624 (80)
Type - ElementType: Pipe Types:Storm:721624
Text - TemperatureRange: 0; InteriorRoughnessCoefficient: 0; PressureRange: 0; WorkingPressure: 0; FluidFlowLeakage: 0; LeakageCurve: 0; NominalDiameter: 1; Gradient: 0; InnerDiameter: 1; OuterDiameter: 1; InvertElevation: 1
Identity Data - Manufacturer: N/A
