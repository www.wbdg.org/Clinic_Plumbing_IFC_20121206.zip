Properties of the parts of a building model (IFC2X3), part 14 of 29

# IfcFlowFitting: Transition - Generic (1079)
Name (M_Transition - Generic:Transition - Generic:Transition - Generic:...) | In | Fitting Outside Radius 1 = Insulation Radius 1 | Width Offset | Visibility 3 | Visibility 1 | Max Fitting Outside Diameter 12 | Visibility 2 | Fitting Outside Radius 2 = Insulation Radius 2 | Height Offset | System Name | System Classification | System Type | Loss Method | Offset (mm) | Level | Host | Mark | Fitting Outside Diameter 2 | OffsetHeight | Length | Nominal Radius 1 | OffsetWidth | Nominal Radius 2 | Tick Size 2 | Tick Size 1 | Fitting Outside Diameter 1 | Size = Overall Size | Nominal Diameter 1 | Nominal Diameter 2
694771 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6734 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
694772 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6735 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
694822 | Level 1 | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6739 | 0.0729167 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0328084 | 0.0291667 | 0.0875 | 0.21875 | 65 mmø-20 mmø | 0.213255 | 0.0656168
694967 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6750 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
694968 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6751 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
694998 | Level 1 | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6755 | 0.0520833 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0246063 | 0.0208333 | 0.0875 | 0.21875 | 65 mmø-15 mmø | 0.213255 | 0.0492126
695101 | Level 1 | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6774 | 0.0520833 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0246063 | 0.0208333 | 0.0875 | 0.21875 | 65 mmø-15 mmø | 0.213255 | 0.0492126
695196 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6783 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
695197 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6784 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
695217 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6785 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
695218 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6786 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
695254 | Level 1 | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6792 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
695346 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6808 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
695347 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6809 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
695376 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6812 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
695377 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6813 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
695422 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6827 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
695921 | Level 2 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 6851 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
696060 | Level 2 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 500 | Level: Level 2 | Level : Level 2 | 6865 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
696143 | Level 2 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 500 | Level: Level 2 | Level : Level 2 | 6876 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
696348 | Level 2 | 0.046875 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 500 | Level: Level 2 | Level : Level 2 | 6909 | 0.177083 | 0.0410105 | 0.0442708 | 0.0410105 | 0.0410105 | 0.082021 | 0.0708333 | 0.0375 | 0.09375 | 50 mmø-25 mmø | 0.082021 | 0.164042
696367 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1460.31 | Level: Level 2 | Level : Level 2 | 6915 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
696416 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6927 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
696519 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6934 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
696520 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6935 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
696626 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6939 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
696730 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6949 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
696731 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6950 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
696767 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6954 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
696846 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6966 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
696847 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6967 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
696870 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6971 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
696964 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6984 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
696965 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6985 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
697029 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 6993 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
697153 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 7009 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
697154 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 7010 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
697173 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 7012 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
697334 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 7029 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
697335 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 7030 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
697357 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 7034 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
697681 | Level 1 | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 7078 | 0.0729167 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0328084 | 0.0291667 | 0.0875 | 0.21875 | 65 mmø-20 mmø | 0.213255 | 0.0656168
697706 | Level 1 | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 7083 | 0.0520833 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0246063 | 0.0208333 | 0.0875 | 0.21875 | 65 mmø-15 mmø | 0.213255 | 0.0492126
697765 | Level 1 | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0885417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 7097 | 0.177083 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.082021 | 0.0708333 | 0.0875 | 0.21875 | 65 mmø-50 mmø | 0.213255 | 0.164042
697957 | Level 1 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.109375 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 7109 | 0.21875 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.106627 | 0.0875 | 0.104167 | 0.260417 | 80 mmø-65 mmø | 0.262467 | 0.213255
698139 | Level 1 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 7122 | 0.0520833 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.0246063 | 0.0208333 | 0.104167 | 0.260417 | 80 mmø-15 mmø | 0.262467 | 0.0492126
698404 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1560 | Level: Level 2 | Level : Level 2 | 7152 | 0.114583 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0524934 | 0.0458333 | 0.1375 | 0.34375 | 100 mmø-32 mmø | 0.328084 | 0.104987
698523 | Level 1 | 0.0260417 | 10 | yes | no | 0.0729167 | no | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 7181 | 0.0729167 | 0.0246063 | 0.0182292 | 0.0246063 | 0.0246063 | 0.0328084 | 0.0291667 | 0.0208333 | 0.0520833 | 20 mmø-15 mmø | 0.0492126 | 0.0656168
698704 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1494.91 | Level: Level 2 | Level : Level 2 | 7196 | 0.114583 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0524934 | 0.0458333 | 0.1375 | 0.34375 | 100 mmø-32 mmø | 0.328084 | 0.104987
698762 | Level 2 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 7205 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
698800 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 7208 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
698806 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 7210 | 0.0729167 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0328084 | 0.0291667 | 0.0541667 | 0.135417 | 40 mmø-20 mmø | 0.131234 | 0.0656168
698812 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 7212 | 0.0729167 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0328084 | 0.0291667 | 0.0541667 | 0.135417 | 40 mmø-20 mmø | 0.131234 | 0.0656168
698896 | Level 2 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 7226 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
698926 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1460.31 | Level: Level 2 | Level : Level 2 | 7240 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
698966 | Level 2 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 7251 | 0.09375 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0410105 | 0.0375 | 0.0541667 | 0.135417 | 40 mmø-25 mmø | 0.131234 | 0.082021
698986 | Level 2 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 7259 | 0.09375 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0410105 | 0.0375 | 0.0541667 | 0.135417 | 40 mmø-25 mmø | 0.131234 | 0.082021
699006 | Level 1 | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 7270 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
699092 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 7275 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
699093 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 7276 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
699133 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 7282 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
699423 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 7296 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
699444 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 7306 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
699462 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1476.19 | Level: Level 2 | Level : Level 2 | 7310 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
699521 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 7328 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
699608 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1476.19 | Level: Level 2 | Level : Level 2 | 7339 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
699800 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 7357 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
699801 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 7358 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
699943 | TOF Footing | 0.0364583 | 10 | yes | no | 0.09375 | no | 0.046875 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7372 | 0.09375 | 0.0328084 | 0.0234375 | 0.0328084 | 0.0328084 | 0.0410105 | 0.0375 | 0.0291667 | 0.0729167 | 25 mmø-20 mmø | 0.0656168 | 0.082021
700029 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7375 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
700030 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7376 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
700135 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7382 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
700247 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7392 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
700248 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7393 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
700318 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7394 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
700573 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7417 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
700596 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7422 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
700690 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7433 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
700691 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7434 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
700758 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7438 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
700939 | TOF Footing | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 7461 | 0.0729167 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0328084 | 0.0291667 | 0.0875 | 0.21875 | 65 mmø-20 mmø | 0.213255 | 0.0656168
701143 | Level 1 | 0.0364583 | 10 | yes | no | 0.09375 | no | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 217.462 | Level: Level 1 | Level : Level 1 | 7483 | 0.09375 | 0.0328084 | 0.0234375 | 0.0328084 | 0.0328084 | 0.0410105 | 0.0375 | 0.0291667 | 0.0729167 | 25 mmø-20 mmø | 0.0656168 | 0.082021
701159 | Level 1 | 0.0364583 | 10 | yes | no | 0.09375 | no | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 217.462 | Level: Level 1 | Level : Level 1 | 7491 | 0.09375 | 0.0328084 | 0.0234375 | 0.0328084 | 0.0328084 | 0.0410105 | 0.0375 | 0.0291667 | 0.0729167 | 25 mmø-20 mmø | 0.0656168 | 0.082021
701199 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7497 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
701200 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7498 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
701330 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 7499 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
701331 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 7500 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
701354 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.046875 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7504 | 0.09375 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0410105 | 0.0375 | 0.0458333 | 0.114583 | 32 mmø-25 mmø | 0.104987 | 0.082021
701355 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.046875 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7505 | 0.09375 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0410105 | 0.0375 | 0.0458333 | 0.114583 | 32 mmø-25 mmø | 0.104987 | 0.082021
701424 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7510 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
701545 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7524 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
701546 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7525 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
701568 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7529 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
701635 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7531 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
701636 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7532 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
701700 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7537 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
701722 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7542 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
701830 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7551 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
701831 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7552 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
701857 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7556 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
701909 | TOF Footing | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 7567 | 0.0520833 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0246063 | 0.0208333 | 0.0875 | 0.21875 | 65 mmø-15 mmø | 0.213255 | 0.0492126
702030 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 7574 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
702031 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 7575 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
702045 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7576 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
702046 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7577 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
702221 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7593 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
702328 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7604 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
702329 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7605 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
702389 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.046875 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7613 | 0.09375 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0410105 | 0.0375 | 0.0458333 | 0.114583 | 32 mmø-25 mmø | 0.104987 | 0.082021
702412 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7619 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
702475 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7642 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
702568 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 7648 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
702576 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 7649 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
702610 | Level 1 | 0.0260417 | 10 | yes | no | 0.0729167 | no | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 356.975 | Level: Level 1 | Level : Level 1 | 7653 | 0.0729167 | 0.0246063 | 0.0182292 | 0.0246063 | 0.0246063 | 0.0328084 | 0.0291667 | 0.0208333 | 0.0520833 | 20 mmø-15 mmø | 0.0492126 | 0.0656168
702631 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -276.187 | Level: Level 1 | Level : Level 1 | 7659 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
702658 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7669 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
702764 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7690 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
702765 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7691 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
702908 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7703 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
703136 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7727 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
703174 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7733 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
703256 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7741 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
703296 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -350 | Level: Level 1 | Level : Level 1 | 7746 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
703321 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7749 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
703322 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7750 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
703361 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -330.156 | Level: Level 1 | Level : Level 1 | 7752 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
703593 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -460.312 | Level: Level 1 | Level : Level 1 | 7788 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
703635 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7798 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
703652 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7799 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
703653 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7800 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
703685 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -350 | Level: Level 1 | Level : Level 1 | 7801 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
703686 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -350 | Level: Level 1 | Level : Level 1 | 7802 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
703716 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7806 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
703759 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7810 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
703893 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -276.187 | Level: Level 1 | Level : Level 1 | 7826 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
703975 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7836 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
703976 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7837 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
704006 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7841 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
704119 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7851 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
704120 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7852 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
704147 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7856 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
704309 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7881 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
704310 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7882 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
704351 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7883 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
704352 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7884 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
704465 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7892 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
704466 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7893 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
704510 | TOF Footing | 0.0260417 | 10 | yes | no | 0.0729167 | no | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7898 | 0.0729167 | 0.0246063 | 0.0182292 | 0.0246063 | 0.0246063 | 0.0328084 | 0.0291667 | 0.0208333 | 0.0520833 | 20 mmø-15 mmø | 0.0492126 | 0.0656168
704553 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 7902 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
704567 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7903 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
704607 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7905 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
704656 | TOF Footing | 0.0364583 | 10 | yes | no | 0.114583 | no | 0.0572917 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 7912 | 0.114583 | 0.0328084 | 0.0286458 | 0.0328084 | 0.0328084 | 0.0524934 | 0.0458333 | 0.0291667 | 0.0729167 | 32 mmø-20 mmø | 0.0656168 | 0.104987
704934 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.046875 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -250 | Level: Level 1 | Level : Level 1 | 7924 | 0.09375 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0410105 | 0.0375 | 0.0458333 | 0.114583 | 32 mmø-25 mmø | 0.104987 | 0.082021
704945 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -250 | Level: Level 1 | Level : Level 1 | 7927 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
704959 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -250 | Level: Level 1 | Level : Level 1 | 7932 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
705101 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -250 | Level: Level 1 | Level : Level 1 | 7953 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
705169 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -250 | Level: Level 1 | Level : Level 1 | 7964 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
705294 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -488.866 | Level: Level 1 | Level : Level 1 | 7983 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
705318 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -250 | Level: Level 1 | Level : Level 1 | 7989 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
705337 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -250 | Level: Level 1 | Level : Level 1 | 7990 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
705338 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -250 | Level: Level 1 | Level : Level 1 | 7991 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
705352 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -250 | Level: Level 1 | Level : Level 1 | 7992 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
705353 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -250 | Level: Level 1 | Level : Level 1 | 7993 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
705379 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -250 | Level: Level 1 | Level : Level 1 | 7997 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
