Properties of the parts of a building model (IFC2X3), part 27 of 29

# IfcFlowSegment: Pipe Types:Waste:577155 (822)
Phasing - Phase Created: New Construction
Other - InstallationDate: N/A; SerialNumber: N/A; BarCode: N/A; WarrantyStartDate: N/A; TagNumber: N/A; AssetIdentifier: N/A; Classification Code: 23-60 30 11 11; Grade: N/A; Classification Description: Pipes for General Use; Size: Size; ExpectedLife: N/A; Material: Material; Reference: Type A - 1; WarrantyGuarantorParts: N/A; WarrantyGuarantorLabor: N/A; WarrantyDurationParts: N/A; Color: White; Constituents: N/A; AssetAccountingType: FIXED; NominalHeight: 0; ModelLabel: N/A; WarrantyDurationLabor: N/A; WarrantyDescription: N/A; NominalLength: 0; ReplacementCost: N/A; Features: N/A; ModelReference: N/A; SustainabilityPerformance: N/A; ProductionYear: N/A; Shape: N/A; CodePerformance: N/A; NominalWidth: 0; AccessibilityPerformance: N/A
Identity Data - Manufacturer: N/A
Name (Pipe Types:Waste:...) | In | Invert Elevation (mm) | Diameter | Section | Area (mm2) | Overall Size = Size | Reference Level | Slope | Offset (mm) = Start Offset (mm) | End Offset (mm) | Outer Diameter | Inner Diameter | Length (mm) | Mark | Fixture Units | Relative Roughness
577155 | Level 1 | -526.251 | 0.164042 | 301 | 21274.6 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 135.438 | 3 | 0 | 20670
577194 | Level 1 | -551.13 | 0.328084 | 272 | 476109 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 1515.5 | 6 | 0 | 40260
577197 | Level 1 | -551.13 | 0.328084 | 562 | 85330.7 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 271.616 | 7 | 0 | 40260
577229 | Level 1 | -538.964 | 0.262467 | 277 | 33709.6 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 134.126 | 8 | 0 | 30680
577249 | Level 1 | -538.964 | 0.262467 | 844 | 47427.1 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 188.706 | 10 | 0 | 30680
577329 | Level 1 | -551.13 | 0.328084 | 255 | 72009.5 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 229.213 | 11 | 0 | 40260
577452 | Level 1 | -526.251 | 0.164042 | 257 | 456420 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 2905.66 | 19 | 0 | 20670
577482 | Level 1 | -551.13 | 0.328084 | 269 | 46871.2 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 149.196 | 20 | 0 | 40260
577489 | Level 1 | -551.13 | 0.328084 | 268 | 94898.3 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 302.071 | 21 | 0 | 40260
577491 | Level 1 | -551.13 | 0.328084 | 269 | 1900412 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 6049.2 | 22 | 0 | 40260
577498 | Level 1 | -551.13 | 0.328084 | 252 | 159021 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 506.178 | 23 | 0 | 40260
577526 | Level 1 | -526.251 | 0.164042 | 283 | 15353.4 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 97.7426 | 24 | 0 | 20670
577582 | Level 1 | -526.251 | 0.164042 | 283 | 159669 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 1016.49 | 26 | 0 | 20670
577599 | Level 1 | -526.251 | 0.164042 | 25 | 342004 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 2177.27 | 27 | 1 | 20670
577661 | Level 1 | -538.964 | 0.262467 | 298 | 4053.33 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 16.1277 | 31 | 0 | 30680
577668 | Level 1 | -551.13 | 0.328084 | 296 | 567156 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 1805.31 | 32 | 0 | 40260
577688 | Level 1 | -526.251 | 0.164042 | 286 | 14220.9 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 90.5333 | 34 | 0 | 20670
577701 | Level 1 | -526.251 | 0.164042 | 286 | 492221 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 3133.57 | 36 | 0 | 20670
577715 | Level 1 | -526.251 | 0.164042 | 433 | 313216 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 1993.99 | 37 | 0 | 20670
577770 | Level 1 | -538.964 | 0.262467 | 236 | 29539.2 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 117.533 | 40 | 0 | 30680
577781 | Level 1 | -538.964 | 0.262467 | 228 | 315004 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 1253.36 | 42 | 0 | 30680
577863 | Level 1 | -526.251 | 0.164042 | 233 | 746586 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 4752.92 | 47 | 0 | 20670
577883 | Level 1 | -520.447 | 0.131234 | 241 | 18619.7 | 40 mmø | Level: Level 1 | 0 | -500 | -500 | 0.158333 | 0.134167 | 148.171 | 48 | 0 | 16100
577903 | Level 1 | -520.447 | 0.131234 | 241 | 240754 | 40 mmø | Level: Level 1 | 0 | -500 | -500 | 0.158333 | 0.134167 | 1915.86 | 50 | 0 | 16100
577940 | Level 1 | -551.13 | 0.328084 | 245 | 65886.5 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 209.723 | 51 | 0 | 40260
577980 | Level 1 | -551.13 | 0.328084 | 243 | 58239.7 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 185.383 | 54 | 0 | 40260
578008 | Level 1 | -551.13 | 0.328084 | 238 | 44538.3 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 141.77 | 57 | 0 | 40260
578015 | Level 1 | -551.13 | 0.328084 | 237 | 841477 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 2678.5 | 58 | 0 | 40260
578017 | Level 1 | -551.13 | 0.328084 | 219 | 613841 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 1953.92 | 59 | 0 | 40260
578022 | Level 1 | -551.13 | 0.328084 | 329 | 447327 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 1423.89 | 60 | 0 | 40260
578054 | Level 1 | -551.13 | 0.328084 | 220 | 55642.6 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 177.116 | 61 | 0 | 40260
578061 | Level 1 | -551.13 | 0.328084 | 238 | 1477031 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 4701.54 | 62 | 0 | 40260
578099 | Level 1 | -551.13 | 0.328084 | 220 | 554992 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 1766.6 | 63 | 0 | 40260
578128 | Level 1 | -551.13 | 0.328084 | 306 | 62046.3 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 197.5 | 64 | 0 | 40260
578137 | Level 1 | -551.13 | 0.328084 | 411 | 1212334 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 3858.98 | 66 | 0 | 40260
578233 | Level 2 | -526.251 | 0.164042 | 407 | 12049.8 | 50 mmø | Level: Level 2 | 0 | -5070 | -5070 | 0.197917 | 0.17225 | 76.7116 | 68 | 0 | 20670
578300 | Level 1 | -551.13 | 0.328084 | 320 | 133744 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 425.719 | 71 | 0 | 40260
578323 | Level 1 | -538.964 | 0.262467 | 414 | 69368.7 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 276.009 | 72 | 0 | 30680
578361 | Level 1 | -538.964 | 0.262467 | 316 | 81951.9 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 326.076 | 76 | 0 | 30680
578391 | Level 1 | -526.251 | 0.164042 | 453 | 111009 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 706.705 | 78 | 0 | 20670
578401 | Level 1 | -526.251 | 0.164042 | 453 | 278049 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 1770.11 | 80 | 0 | 20670
578411 | Level 1 | -551.13 | 0.328084 | 326 | 88786.9 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 282.617 | 81 | 0 | 40260
578435 | Level 1 | -551.13 | 0.328084 | 458 | 149549 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 476.031 | 84 | 0 | 40260
578500 | Level 1 | -526.251 | 0.164042 | 459 | 11184.7 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 71.2042 | 88 | 0 | 20670
578511 | Level 1 | -526.251 | 0.164042 | 151 | 31610.8 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 201.241 | 90 | 2 | 20670
578541 | Level 1 | -526.251 | 0.164042 | 322 | 36526.8 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 232.537 | 91 | 0 | 20670
578553 | Level 1 | -526.251 | 0.164042 | 322 | 536208 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 3413.61 | 93 | 0 | 20670
578567 | Level 1 | -538.964 | 0.262467 | 313 | 65573.8 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 260.91 | 94 | 0 | 30680
578587 | Level 1 | -538.964 | 0.262467 | 208 | 159515 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 634.689 | 97 | 2 | 30680
578613 | Level 1 | -526.251 | 0.164042 | 169 | 30566.3 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 194.591 | 100 | 2 | 20670
578642 | Level 1 | -526.251 | 0.164042 | 315 | 128815 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 820.063 | 103 | 0 | 20670
624183 | Level 1 | -476.188 | 0.104987 | 1 | 119550 | 32 mmø | Level: Level 1 |  | -476.188 | 713 | 0.138333 | 0.115 | 1189.19 | 105 | 1 | 13800
624188 | Level 1 | -517.526 | 0.104987 | 1 | 17459.5 | 32 mmø | Level: Level 1 | 0 | -500 | -500 | 0.138333 | 0.115 | 173.673 | 106 | 1 | 13800
624275 | Level 1 | -476.188 | 0.104987 | 168 | 109324 | 32 mmø | Level: Level 1 |  | -476.187 | 611.275 | 0.138333 | 0.115 | 1087.46 | 109 | 2 | 13800
624348 | Level 1 | -476.188 | 0.104987 | 410 | 76993.5 | 32 mmø | Level: Level 1 |  | 289.681 | -476.188 | 0.138333 | 0.115 | 765.869 | 110 | 0 | 13800
624533 | Level 1 | -526.251 | 0.164042 | 154 | 72409.8 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 460.975 | 120 | 2 | 20670
624544 | Level 1 | -526.251 | 0.164042 | 154 | 36650.5 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 233.324 | 122 | 2 | 20670
624550 | Level 1 | -476.188 | 0.104987 | 153 | 108190 | 32 mmø | Level: Level 1 |  | -476.188 | 600 | 0.138333 | 0.115 | 1076.19 | 123 | 2 | 13800
624588 | Level 1 | -466.663 | 0.164042 | 453 | 838281 | 50 mmø | Level: Level 1 |  | -466.663 | 4870 | 0.197917 | 0.17225 | 5336.66 | 125 | 0 | 20670
625091 | Level 1 | 473.749 | 0.164042 | 151 | 54342.7 | 50 mmø | Level: Level 1 | 0 | 500 | 500 | 0.197917 | 0.17225 | 345.956 | 131 | 2 | 20670
625100 | Level 1 | -466.663 | 0.164042 | 151 | 146606 | 50 mmø | Level: Level 1 |  | -466.663 | 466.663 | 0.197917 | 0.17225 | 933.325 | 132 | 2 | 20670
625105 | Level 1 | 473.749 | 0.164042 | 151 | 37684.4 | 50 mmø | Level: Level 1 | 0 | 500 | 500 | 0.197917 | 0.17225 | 239.906 | 133 | 2 | 20670
625125 | Level 1 | 523.812 | 0.104987 | 150 | 7659.2 | 32 mmø | Level: Level 1 |  | 523.812 | 600 | 0.138333 | 0.115 | 76.1875 | 134 | 2 | 13800
625172 | Level 1 | -476.188 | 0.104987 | 3 | 119550 | 32 mmø | Level: Level 1 |  | 713 | -476.188 | 0.138333 | 0.115 | 1189.19 | 135 | 1 | 13800
625173 | Level 1 | -517.526 | 0.104987 | 3 | 17355.3 | 32 mmø | Level: Level 1 | 0 | -500 | -500 | 0.138333 | 0.115 | 172.636 | 136 | 1 | 13800
625182 | Level 1 | -526.251 | 0.164042 | 4 | 910950 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 5799.29 | 138 | 1 | 20670
625205 | Level 1 | -441.263 | 0.328084 | 458 | 132143 | 100 mmø | Level: Level 1 |  | -441.263 | -20.6375 | 0.375 | 0.3355 | 420.625 | 140 | 0 | 40260
625244 | Level 1 | -466.663 | 0.164042 | 233 | 838281 | 50 mmø | Level: Level 1 |  | -466.663 | 4870 | 0.197917 | 0.17225 | 5336.66 | 142 | 0 | 20670
625287 | Level 1 | -526.251 | 0.164042 | 176 | 255814 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 1628.56 | 146 | 2 | 20670
625343 | Level 1 | -526.251 | 0.164042 | 248 | 12193.6 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 77.6267 | 147 | 0 | 20670
625354 | Level 1 | -526.251 | 0.164042 | 16 | 149297 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 950.451 | 149 | 1 | 20670
625363 | Level 1 | -526.251 | 0.164042 | 16 | 52960.4 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 337.156 | 150 | 1 | 20670
625371 | Level 1 | -476.188 | 0.104987 | 15 | 119550 | 32 mmø | Level: Level 1 |  | 713 | -476.188 | 0.138333 | 0.115 | 1189.19 | 151 | 1 | 13800
625382 | Level 1 | 123.812 | 0.104987 | 9 | 59231.6 | 32 mmø | Level: Level 1 |  | 713 | 123.812 | 0.138333 | 0.115 | 589.187 | 152 | 1 | 13800
625387 | Level 1 | 82.474 | 0.104987 | 9 | 38725.8 | 32 mmø | Level: Level 1 | 0 | 100 | 100 | 0.138333 | 0.115 | 385.213 | 153 | 1 | 13800
625397 | Level 1 | -551.13 | 0.328084 | 249 | 179340 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 570.855 | 155 | 0 | 40260
625736 | Level 1 | -551.13 | 0.328084 | 245 | 563068 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 1792.3 | 162 | 0 | 40260
626014 | Level 1 | -434.913 | 0.328084 | 10 | 152338 | 100 mmø | Level: Level 1 |  | 49.9937 | -434.912 | 0.375 | 0.3355 | 484.906 | 169 | 1 | 40260
626256 | Level 1 | 181.802 | 0.328084 | 14 | 59507.2 | 100 mmø | Level: Level 1 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 189.417 | 170 | 4 | 40260
626351 | Level 1 | -351.13 | 0.328084 | 7 | 124462 | 100 mmø | Level: Level 1 | 0 | -300 | -300 | 0.375 | 0.3355 | 396.175 | 175 | 1 | 40260
626357 | Level 1 | -351.13 | 0.328084 | 7 | 179708 | 100 mmø | Level: Level 1 | 0 | -300 | -300 | 0.375 | 0.3355 | 572.03 | 176 | 1 | 40260
626362 | Level 1 | -351.13 | 0.328084 | 7 | 42399 | 100 mmø | Level: Level 1 | 0 | -300 | -300 | 0.375 | 0.3355 | 134.96 | 177 | 1 | 40260
626387 | Level 1 | -215.069 | 0.104987 | 6 | 93299.6 | 32 mmø | Level: Level 1 |  | 713 | -215.069 | 0.138333 | 0.115 | 928.069 | 178 | 1 | 13800
626427 | Level 1 | 181.802 | 0.328084 | 17 | 58348.7 | 100 mmø | Level: Level 1 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 185.73 | 181 | 4 | 40260
626428 | Level 1 | 181.802 | 0.328084 | 17 | 212265 | 100 mmø | Level: Level 1 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 675.659 | 182 | 4 | 40260
626431 | Level 1 | -434.913 | 0.328084 | 17 | 191357 | 100 mmø | Level: Level 1 |  | -434.912 | 174.195 | 0.375 | 0.3355 | 609.107 | 183 | 4 | 40260
626783 | Level 1 | -476.188 | 0.104987 | 19 | 119550 | 32 mmø | Level: Level 1 |  | 713 | -476.188 | 0.138333 | 0.115 | 1189.19 | 187 | 1 | 13800
626784 | Level 1 | -517.526 | 0.104987 | 19 | 37897.9 | 32 mmø | Level: Level 1 | 0 | -500 | -500 | 0.138333 | 0.115 | 376.977 | 188 | 1 | 13800
626813 | Level 1 | -441.263 | 0.328084 | 431 | 132143 | 100 mmø | Level: Level 1 |  | -441.263 | -20.6375 | 0.375 | 0.3355 | 420.625 | 192 | 0 | 40260
626853 | Level 1 | -551.13 | 0.328084 | 330 | 4515.15 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 14.3722 | 193 | 0 | 40260
626863 | Level 1 | -551.13 | 0.328084 | 330 | 1285993 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 4093.44 | 195 | 0 | 40260
626905 | Level 1 | -441.263 | 0.328084 | 330 | 132143 | 100 mmø | Level: Level 1 |  | -441.263 | -20.6375 | 0.375 | 0.3355 | 420.625 | 197 | 0 | 40260
626940 | Level 1 | -441.263 | 0.328084 | 220 | 132143 | 100 mmø | Level: Level 1 |  | -441.263 | -20.6375 | 0.375 | 0.3355 | 420.625 | 199 | 0 | 40260
626979 | Level 1 | -441.263 | 0.328084 | 234 | 132143 | 100 mmø | Level: Level 1 |  | -441.263 | -20.6375 | 0.375 | 0.3355 | 420.625 | 201 | 0 | 40260
627024 | Level 1 | -415.069 | 0.262467 | 230 | 82972.6 | 80 mmø | Level: Level 1 |  | -415.069 | -84.9312 | 0.291667 | 0.255667 | 330.138 | 203 | 0 | 30680
627157 | Level 1 | -476.188 | 0.104987 | 173 | 108190 | 32 mmø | Level: Level 1 |  | -476.188 | 600 | 0.138333 | 0.115 | 1076.19 | 204 | 2 | 13800
627197 | Level 1 | -441.263 | 0.328084 | 562 | 1424767 | 100 mmø | Level: Level 1 |  | -441.263 | 4093.91 | 0.375 | 0.3355 | 4535.18 | 206 | 0 | 40260
627226 | Level 1 | -520.447 | 0.131234 | 22 | 51105.1 | 40 mmø | Level: Level 1 | 0 | -500 | -500 | 0.158333 | 0.134167 | 406.681 | 207 | 1 | 16100
627235 | Level 1 | -476.188 | 0.104987 | 21 | 119550 | 32 mmø | Level: Level 1 |  | 713 | -476.188 | 0.138333 | 0.115 | 1189.19 | 208 | 1 | 13800
627239 | Level 1 | -520.447 | 0.131234 | 22 | 119211 | 40 mmø | Level: Level 1 | 0 | -500 | -500 | 0.158333 | 0.134167 | 948.651 | 209 | 1 | 16100
627254 | Level 1 | -459.519 | 0.131234 | 275 | 16654.4 | 40 mmø | Level: Level 1 |  | -326.987 | -459.519 | 0.158333 | 0.134167 | 132.531 | 210 | 0 | 16100
627285 | Level 1 | -466.663 | 0.164042 | 283 | 73303.2 | 50 mmø | Level: Level 1 |  | -466.663 | 0 | 0.197917 | 0.17225 | 466.663 | 213 | 0 | 20670
627369 | Level 1 | -466.663 | 0.164042 | 847 | 19820.5 | 50 mmø | Level: Level 1 |  | -466.663 | -340.481 | 0.197917 | 0.17225 | 126.181 | 217 | 0 | 20670
627406 | Level 1 | -479.363 | 0.164042 | 226 | 22812.9 | 50 mmø | Level: Level 1 |  | -479.363 | -334.131 | 0.197917 | 0.17225 | 145.231 | 221 | 0 | 20670
627462 | Level 1 | -551.13 | 0.328084 | 258 | 132249 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 420.961 | 225 | 0 | 40260
627469 | Level 1 | -526.251 | 0.164042 | 28 | 20269.3 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 129.038 | 226 | 1 | 20670
627484 | Level 1 | -476.188 | 0.104987 | 27 | 119550 | 32 mmø | Level: Level 1 |  | 713 | -476.188 | 0.138333 | 0.115 | 1189.19 | 228 | 1 | 13800
627532 | Level 1 | -551.13 | 0.328084 | 267 | 123134 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 391.949 | 233 | 0 | 40260
627555 | Level 1 | -51.1302 | 0.328084 | 605 | 38404 | 100 mmø | Level: Level 1 | 0 | 0 | 0 | 0.375 | 0.3355 | 122.244 | 235 | 0 | 40260
627600 | Level 1 | -441.263 | 0.328084 | 267 | 120174 | 100 mmø | Level: Level 1 |  | -58.7375 | -441.263 | 0.375 | 0.3355 | 382.525 | 238 | 0 | 40260
627627 | Level 1 | 23.8125 | 0.104987 | 29 | 69284.7 | 32 mmø | Level: Level 1 |  | 713 | 23.8125 | 0.138333 | 0.115 | 689.188 | 239 | 1 | 13800
627628 | Level 1 | -17.526 | 0.104987 | 29 | 33695.5 | 32 mmø | Level: Level 1 | 0 | 0 | 0 | 0.138333 | 0.115 | 335.175 | 240 | 1 | 13800
627717 | Level 1 | 181.802 | 0.328084 | 31 | 45949.7 | 100 mmø | Level: Level 1 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 146.262 | 241 | 4 | 40260
627718 | Level 1 | 65.0875 | 0.328084 | 31 | 34277.1 | 100 mmø | Level: Level 1 |  | 174.195 | 65.0875 | 0.375 | 0.3355 | 109.107 | 242 | 4 | 40260
627726 | Level 1 | -51.1302 | 0.328084 | 267 | 11280.8 | 100 mmø | Level: Level 1 | 0 | 0 | 0 | 0.375 | 0.3355 | 35.9079 | 244 | 0 | 40260
627751 | Level 1 | -26.2509 | 0.164042 | 36 | 36350.2 | 50 mmø | Level: Level 1 | 0 | 0 | 0 | 0.197917 | 0.17225 | 231.412 | 245 | 1 | 20670
627756 | Level 1 | 23.8125 | 0.104987 | 35 | 69284.7 | 32 mmø | Level: Level 1 |  | 23.8125 | 713 | 0.138333 | 0.115 | 689.188 | 246 | 1 | 13800
627771 | Level 1 | -551.13 | 0.328084 | 255 | 824178 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 2623.44 | 249 | 0 | 40260
627861 | Level 1 | 181.802 | 0.328084 | 38 | 34547.7 | 100 mmø | Level: Level 1 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 109.969 | 252 | 4 | 40260
627867 | Level 1 | -408.719 | 0.262467 | 260 | 89555.8 | 80 mmø | Level: Level 1 |  | -52.3875 | -408.719 | 0.291667 | 0.255667 | 356.331 | 254 | 0 | 30680
627905 | Level 1 | -551.13 | 0.328084 | 221 | 103257 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 328.676 | 255 | 0 | 40260
627918 | Level 1 | -551.13 | 0.328084 | 222 | 79674.6 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 253.612 | 256 | 0 | 40260
627927 | Level 1 | -551.13 | 0.328084 | 888 | 33082.6 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 105.305 | 258 | 0 | 40260
627948 | Level 1 | -551.13 | 0.328084 | 388 | 42981 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 136.813 | 259 | 0 | 40260
628016 | Level 1 | 2946.89 | 0.328084 | 866 | 324362 | 100 mmø | Level: Level 1 |  | 2946.89 | 3979.36 | 0.375 | 0.3355 | 1032.47 | 263 | 0 | 40260
628063 | Level 1 | -551.13 | 0.328084 | 392 | 36746.3 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 116.967 | 264 | 0 | 40260
628099 | Level 1 | -441.263 | 0.328084 | 380 | 132143 | 100 mmø | Level: Level 1 |  | -441.263 | -20.6375 | 0.375 | 0.3355 | 420.625 | 268 | 0 | 40260
628306 | Level 1 | -551.13 | 0.328084 | 393 | 1001458 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 3187.74 | 269 | 0 | 40260
628428 | Level 1 | -551.13 | 0.328084 | 381 | 104710 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 333.301 | 271 | 0 | 40260
628614 | Level 1 | -434.913 | 0.328084 | 715 | 1023523 | 100 mmø | Level: Level 1 |  | 2823.06 | -434.912 | 0.375 | 0.3355 | 3257.98 | 277 | 0 | 40260
628707 | Level 1 | 181.802 | 0.328084 | 535 | 6969.67 | 100 mmø | Level: Level 1 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 22.1851 | 279 | 0 | 40260
628709 | Level 1 | -434.913 | 0.328084 | 535 | 191357 | 100 mmø | Level: Level 1 |  | 174.195 | -434.912 | 0.375 | 0.3355 | 609.107 | 280 | 0 | 40260
628727 | Level 1 | -476.188 | 0.104987 | 538 | 42525.2 | 32 mmø | Level: Level 1 |  | -53.1813 | -476.188 | 0.138333 | 0.115 | 423.006 | 282 | 0 | 13800
628728 | Level 1 | -517.526 | 0.104987 | 538 | 29756.1 | 32 mmø | Level: Level 1 | 0 | -500 | -500 | 0.138333 | 0.115 | 295.989 | 283 | 0 | 13800
628742 | Level 1 | -526.251 | 0.164042 | 493 | 17756.2 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 113.04 | 286 | 0 | 20670
628757 | Level 1 | -526.251 | 0.164042 | 83 | 2898.71 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 18.4538 | 288 | 1 | 20670
628877 | Level 1 | -476.188 | 0.104987 | 82 | 119550 | 32 mmø | Level: Level 1 |  | 713 | -476.188 | 0.138333 | 0.115 | 1189.19 | 289 | 1 | 13800
628878 | Level 1 | -517.526 | 0.104987 | 82 | 19474.9 | 32 mmø | Level: Level 1 | 0 | -500 | -500 | 0.138333 | 0.115 | 193.721 | 290 | 1 | 13800
628888 | Level 1 | -538.964 | 0.262467 | 386 | 25715.9 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 102.32 | 291 | 0 | 30680
628895 | Level 1 | -551.13 | 0.328084 | 384 | 1306113 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 4157.49 | 292 | 0 | 40260
628901 | Level 1 | -538.964 | 0.262467 | 216 | 43692.8 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 173.848 | 293 | 2 | 30680
628910 | Level 1 | -538.964 | 0.262467 | 216 | 25820.6 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 102.737 | 294 | 2 | 30680
628930 | Level 1 | 181.802 | 0.328084 | 73 | 37343.9 | 100 mmø | Level: Level 1 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 118.869 | 296 | 4 | 40260
628932 | Level 1 | -441.263 | 0.328084 | 73 | 193352 | 100 mmø | Level: Level 1 |  | 174.195 | -441.263 | 0.375 | 0.3355 | 615.457 | 297 | 4 | 40260
628942 | Level 1 | 181.802 | 0.328084 | 72 | 37343.9 | 100 mmø | Level: Level 1 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 118.869 | 298 | 4 | 40260
628944 | Level 1 | -434.913 | 0.328084 | 72 | 191357 | 100 mmø | Level: Level 1 |  | 174.195 | -434.912 | 0.375 | 0.3355 | 609.107 | 299 | 4 | 40260
628960 | Level 1 | 181.802 | 0.328084 | 74 | 36254 | 100 mmø | Level: Level 1 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 115.4 | 301 | 4 | 40260
628979 | Level 1 | -466.663 | 0.164042 | 75 | 112171 | 50 mmø | Level: Level 1 |  | 247.438 | -466.663 | 0.197917 | 0.17225 | 714.1 | 305 | 4 | 20670
628996 | Level 1 | -526.251 | 0.164042 | 379 | 28344.2 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 180.445 | 307 | 0 | 20670
629007 | Level 1 | -526.251 | 0.164042 | 379 | 411725 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 2621.12 | 309 | 0 | 20670
629016 | Level 1 | -526.251 | 0.164042 | 81 | 25455.7 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 162.056 | 310 | 1 | 20670
629022 | Level 1 | -476.188 | 0.104987 | 80 | 119550 | 32 mmø | Level: Level 1 |  | 713 | -476.188 | 0.138333 | 0.115 | 1189.19 | 311 | 1 | 13800
629026 | Level 1 | -526.251 | 0.164042 | 78 | 11270.7 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 71.7516 | 312 | 1 | 20670
629037 | Level 1 | -526.251 | 0.164042 | 78 | 295477 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 1881.06 | 314 | 1 | 20670
629046 | Level 1 | -526.251 | 0.164042 | 78 | 31890.5 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 203.021 | 315 | 1 | 20670
629056 | Level 1 | -476.188 | 0.104987 | 77 | 119550 | 32 mmø | Level: Level 1 |  | 713 | -476.188 | 0.138333 | 0.115 | 1189.19 | 316 | 1 | 13800
629092 | Level 1 | -442.386 | 0.328084 | 344 | 132496 | 100 mmø | Level: Level 1 |  | -442.386 | -20.6375 | 0.375 | 0.3355 | 421.748 | 319 | 0 | 40260
629112 | Level 1 | -527.374 | 0.164042 | 346 | 37007.1 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 235.594 | 320 | 0 | 20670
629164 | Level 1 | 532.474 | 0.104987 | 143 | 21231.3 | 32 mmø | Level: Level 1 | 0 | 550 | 550 | 0.138333 | 0.115 | 211.191 | 325 | 2 | 13800
629184 | Level 1 | -26.2509 | 0.164042 | 148 | 23223.8 | 50 mmø | Level: Level 1 | 0 | 0 | 0 | 0.197917 | 0.17225 | 147.848 | 326 | 2 | 20670
629193 | Level 1 | 23.8125 | 0.104987 | 147 | 59058.2 | 32 mmø | Level: Level 1 |  | 23.8125 | 611.275 | 0.138333 | 0.115 | 587.463 | 327 | 2 | 13800
629291 | Level 1 | -552.254 | 0.328084 | 776 | 42987.2 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 136.833 | 330 | 0 | 40260
629459 | Level 1 | 181.802 | 0.328084 | 57 | 42221.9 | 100 mmø | Level: Level 1 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 134.397 | 336 | 4 | 40260
629460 | Level 1 | 181.802 | 0.328084 | 57 | 53949 | 100 mmø | Level: Level 1 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 171.725 | 337 | 4 | 40260
629463 | Level 1 | -442.386 | 0.328084 | 57 | 193705 | 100 mmø | Level: Level 1 |  | -442.386 | 174.195 | 0.375 | 0.3355 | 616.581 | 338 | 4 | 40260
629482 | Level 1 | -477.311 | 0.104987 | 59 | 109437 | 32 mmø | Level: Level 1 |  | -477.311 | 611.275 | 0.138333 | 0.115 | 1088.59 | 339 | 2 | 13800
629483 | Level 1 | -518.649 | 0.104987 | 59 | 25089.6 | 32 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.138333 | 0.115 | 249.571 | 340 | 2 | 13800
629510 | Level 1 | -518.649 | 0.104987 | 55 | 25720.4 | 32 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.138333 | 0.115 | 255.845 | 344 | 1 | 13800
629514 | Level 1 | -552.254 | 0.328084 | 777 | 1430148 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 4552.3 | 345 | 0 | 40260
629526 | Level 1 | -552.254 | 0.328084 | 349 | 83838.4 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 266.866 | 347 | 0 | 40260
629578 | Level 1 | -442.387 | 0.328084 | 331 | 132496 | 100 mmø | Level: Level 1 |  | -442.386 | -20.6375 | 0.375 | 0.3355 | 421.748 | 351 | 0 | 40260
629672 | Level 1 | -455.086 | 0.262467 | 336 | 109189 | 80 mmø | Level: Level 1 |  | -455.086 | -20.6375 | 0.291667 | 0.255667 | 434.448 | 355 | 0 | 30680
629737 | Level 1 | 261.036 | 0.262467 | 67 | 47829.2 | 80 mmø | Level: Level 1 | 0 | 300 | 300 | 0.291667 | 0.255667 | 190.306 | 356 | 1 | 30680
629746 | Level 1 | 323.812 | 0.104987 | 66 | 39125.4 | 32 mmø | Level: Level 1 |  | 323.812 | 713 | 0.138333 | 0.115 | 389.188 | 357 | 1 | 13800
629750 | Level 1 | 261.036 | 0.262467 | 67 | 30809 | 80 mmø | Level: Level 1 | 0 | 300 | 300 | 0.291667 | 0.255667 | 122.585 | 358 | 1 | 30680
629757 | Level 1 | -448.736 | 0.262467 | 466 | 176607 | 80 mmø | Level: Level 1 |  | 253.963 | -448.736 | 0.291667 | 0.255667 | 702.698 | 359 | 0 | 30680
629783 | Level 1 | -552.254 | 0.328084 | 69 | 53006.7 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 168.725 | 361 | 4 | 40260
629792 | Level 1 | -552.254 | 0.328084 | 331 | 72521.7 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 230.844 | 362 | 0 | 40260
629891 | Level 1 | -420.654 | 0.328084 | 69 | 186640 | 100 mmø | Level: Level 1 | 1742.45 | -420.625 | 173.468 | 0.375 | 0.3355 | 594.093 | 365 | 4 | 40260
629933 | Level 1 | -552.254 | 0.328084 | 341 | 94661 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 301.315 | 367 | 0 | 40260
629970 | Level 1 | 181.802 | 0.328084 | 338 | 17563.4 | 100 mmø | Level: Level 1 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 55.9062 | 370 | 0 | 40260
629972 | Level 1 | -442.386 | 0.328084 | 338 | 193705 | 100 mmø | Level: Level 1 |  | 174.195 | -442.386 | 0.375 | 0.3355 | 616.581 | 371 | 0 | 40260
629989 | Level 1 | -477.311 | 0.104987 | 62 | 119663 | 32 mmø | Level: Level 1 |  | 713 | -477.311 | 0.138333 | 0.115 | 1190.31 | 372 | 1 | 13800
629990 | Level 1 | -518.649 | 0.104987 | 472 | 3005.42 | 32 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.138333 | 0.115 | 29.8955 | 373 | 0 | 13800
629994 | Level 1 | -552.254 | 0.328084 | 341 | 37384.3 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 118.998 | 374 | 0 | 40260
630105 | Level 1 | -552.254 | 0.328084 | 333 | 26369.6 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 83.9371 | 376 | 0 | 40260
630116 | Level 1 | -480.486 | 0.082021 | 70 | 37737.3 | 25 mmø | Level: Level 1 |  | 0 | -480.486 | 0.109583 | 0.0874167 | 480.486 | 378 | 2 | 10490
630125 | Level 1 | -527.374 | 0.164042 | 475 | 27068.6 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 172.324 | 380 | 0 | 20670
630132 | Level 1 | -552.254 | 0.328084 | 342 | 689990 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 2196.31 | 381 | 0 | 40260
630138 | Level 1 | -527.374 | 0.164042 | 65 | 8987.39 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 57.2155 | 382 | 1 | 20670
630158 | Level 1 | -477.311 | 0.104987 | 64 | 119663 | 32 mmø | Level: Level 1 |  | 713 | -477.311 | 0.138333 | 0.115 | 1190.31 | 383 | 1 | 13800
630159 | Level 1 | -518.649 | 0.104987 | 64 | 14011 | 32 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.138333 | 0.115 | 139.37 | 384 | 1 | 13800
630169 | Level 1 | -527.374 | 0.164042 | 353 | 10051.9 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 63.9924 | 385 | 0 | 20670
630176 | Level 1 | -552.254 | 0.328084 | 351 | 1211703 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 3856.97 | 386 | 0 | 40260
630194 | Level 1 | -447.942 | 0.104987 | 52 | 116711 | 32 mmø | Level: Level 1 |  | 713 | -447.942 | 0.138333 | 0.115 | 1160.94 | 388 | 1 | 13800
630230 | Level 1 | -527.374 | 0.164042 | 502 | 24821.1 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 158.016 | 389 | 0 | 20670
630239 | Level 1 | -527.374 | 0.164042 | 501 | 313646 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 1996.73 | 391 | 0 | 20670
630250 | Level 1 | -527.374 | 0.164042 | 501 | 27036.3 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 172.118 | 392 | 0 | 20670
630256 | Level 1 | -477.311 | 0.104987 | 359 | 44952.3 | 32 mmø | Level: Level 1 |  | -30.1625 | -477.311 | 0.138333 | 0.115 | 447.148 | 393 | 0 | 13800
630505 | Level 1 | -540.087 | 0.262467 | 895 | 64324.9 | 80 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.291667 | 0.255667 | 255.941 | 406 | 0 | 30680
630530 | Level 1 | -527.374 | 0.164042 | 509 | 15873.5 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 101.054 | 408 | 0 | 20670
630541 | Level 1 | -527.374 | 0.164042 | 510 | 493282 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 3140.33 | 410 | 0 | 20670
630548 | Level 1 | -527.374 | 0.164042 | 510 | 7322.15 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 46.6142 | 411 | 0 | 20670
630570 | Level 1 | -480.486 | 0.104987 | 50 | 119982 | 32 mmø | Level: Level 1 |  | 713 | -480.486 | 0.138333 | 0.115 | 1193.49 | 412 | 1 | 13800
630588 | Level 1 | -448.074 | 0.104987 | 48 | 116712 | 32 mmø | Level: Level 1 | 103.025 | 713 | -447.904 | 0.138333 | 0.115 | 1160.96 | 415 | 1 | 13800
630595 | Level 1 | -552.254 | 0.328084 | 365 | 58527.2 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 186.298 | 417 | 0 | 40260
630602 | Level 1 | -552.254 | 0.328084 | 364 | 481743 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 1533.44 | 418 | 0 | 40260
630633 | Level 1 | -442.386 | 0.328084 | 372 | 132496 | 100 mmø | Level: Level 1 |  | -442.386 | -20.6375 | 0.375 | 0.3355 | 421.748 | 421 | 0 | 40260
630736 | Level 1 | -552.254 | 0.328084 | 374 | 74378.1 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 236.753 | 426 | 0 | 40260
630828 | Level 1 | -442.386 | 0.328084 | 373 | 118532 | 100 mmø | Level: Level 1 |  | -442.386 | -65.0875 | 0.375 | 0.3355 | 377.298 | 430 | 0 | 40260
630847 | Level 1 | 23.8125 | 0.104987 | 41 | 69284.7 | 32 mmø | Level: Level 1 |  | 713 | 23.8125 | 0.138333 | 0.115 | 689.188 | 431 | 1 | 13800
630848 | Level 1 | -17.526 | 0.104987 | 41 | 30961.3 | 32 mmø | Level: Level 1 | 0 | 0 | 0 | 0.138333 | 0.115 | 307.977 | 432 | 1 | 13800
631026 | Level 1 | -51.1302 | 0.328084 | 43 | 42780.6 | 100 mmø | Level: Level 1 | 0 | 0 | 0 | 0.375 | 0.3355 | 136.175 | 433 | 4 | 40260
631076 | Level 1 | 58.7375 | 0.328084 | 43 | 36272 | 100 mmø | Level: Level 1 |  | 58.7375 | 174.195 | 0.375 | 0.3355 | 115.457 | 437 | 4 | 40260
631109 | Level 1 | 181.802 | 0.328084 | 43 | 37405.3 | 100 mmø | Level: Level 1 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 119.065 | 438 | 4 | 40260
631143 | Level 1 | -527.374 | 0.164042 | 223 | 18812.9 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 119.767 | 439 | 0 | 20670
631154 | Level 1 | -527.374 | 0.164042 | 223 | 986753 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 6281.86 | 441 | 0 | 20670
631167 | Level 1 | -226.251 | 0.164042 | 223 | 26969.6 | 50 mmø | Level: Level 1 | 0 | -200 | -200 | 0.197917 | 0.17225 | 171.694 | 442 | 0 | 20670
631194 | Level 1 | -467.786 | 0.164042 | 223 | 36827.1 | 50 mmø | Level: Level 1 |  | -233.338 | -467.786 | 0.197917 | 0.17225 | 234.448 | 443 | 0 | 20670
631200 | Level 1 | -179.363 | 0.104987 | 545 | 14999.2 | 32 mmø | Level: Level 1 |  | -30.1625 | -179.363 | 0.138333 | 0.115 | 149.2 | 444 | 0 | 13800
631206 | Level 1 | -552.254 | 0.328084 | 366 | 52243.8 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 166.297 | 445 | 0 | 40260
631215 | Level 1 | -552.254 | 0.328084 | 366 | 392783 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 1250.27 | 447 | 0 | 40260
631242 | Level 1 | -442.386 | 0.328084 | 366 | 1025871 | 100 mmø | Level: Level 1 |  | 2823.06 | -442.386 | 0.375 | 0.3355 | 3265.45 | 449 | 0 | 40260
631263 | Level 1 | -527.374 | 0.164042 | 369 | 39367.9 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 250.624 | 450 | 0 | 20670
631274 | Level 1 | -527.374 | 0.164042 | 369 | 564836 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 3595.86 | 452 | 0 | 20670
631281 | Level 1 | -527.374 | 0.164042 | 369 | 33332.4 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 212.201 | 453 | 0 | 20670
631293 | Level 1 | -477.311 | 0.104987 | 370 | 43595.7 | 32 mmø | Level: Level 1 |  | -43.6563 | -477.311 | 0.138333 | 0.115 | 433.655 | 454 | 0 | 13800
631298 | Level 1 | -526.662 | 0.164042 | 225 | 17152.1 | 50 mmø | Level: Level 1 | 0.00338827 | -500.042 | -500.412 | 0.197917 | 0.17225 | 109.194 | 455 | 0 | 20670
631323 | Level 1 | -526.251 | 0.164042 | 225 | 188983 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 1203.1 | 456 | 0 | 20670
631330 | Level 1 | -526.251 | 0.164042 | 225 | 33751.3 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 214.867 | 457 | 0 | 20670
631337 | Level 1 | -479.363 | 0.104987 | 224 | 76138.4 | 32 mmø | Level: Level 1 |  | 278 | -479.363 | 0.138333 | 0.115 | 757.363 | 458 | 0 | 13800
631375 | Level 1 | -538.964 | 0.262467 | 298 | 412241 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 1640.26 | 462 | 0 | 30680
631410 | Level 1 | -526.251 | 0.164042 | 174 | 37435.8 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 238.324 | 467 | 2 | 20670
631550 | Level 1 | -466.688 | 0.164042 | 286 | 19821.5 | 50 mmø | Level: Level 1 | 2381.21 | -466.677 | -340.489 | 0.197917 | 0.17225 | 126.187 | 474 | 0 | 20670
632014 | Level 1 | -526.251 | 0.164042 | 25 | 126041 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 802.399 | 489 | 1 | 20670
632061 | Level 1 | -476.188 | 0.104987 | 24 | 119550 | 32 mmø | Level: Level 1 |  | 713 | -476.188 | 0.138333 | 0.115 | 1189.19 | 490 | 1 | 13800
632062 | Level 1 | -517.526 | 0.104987 | 24 | 23036.5 | 32 mmø | Level: Level 1 | 0 | -500 | -500 | 0.138333 | 0.115 | 229.148 | 491 | 1 | 13800
632549 | Level 1 | 255.775 | 0.104987 | 32 | 45965.3 | 32 mmø | Level: Level 1 |  | 713 | 255.775 | 0.138333 | 0.115 | 457.225 | 509 | 1 | 13800
632550 | Level 1 | 214.437 | 0.104987 | 33 | 12202.3 | 32 mmø | Level: Level 1 | 0 | 231.963 | 231.963 | 0.138333 | 0.115 | 121.379 | 510 | 1 | 13800
632595 | Level 1 | 2882.47 | 0.104987 | 253 | 310657 | 32 mmø | Level: Level 1 | 0 | 2900 | 2900 | 0.138333 | 0.115 | 3090.17 | 513 | 0 | 13800
632606 | Level 1 | 2882.47 | 0.104987 | 253 | 29562.4 | 32 mmø | Level: Level 1 | 0 | 2900 | 2900 | 0.138333 | 0.115 | 294.063 | 515 | 0 | 13800
633191 | Level 1 | -526.251 | 0.164042 | 233 | 44859.1 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 285.582 | 522 | 0 | 20670
633198 | Level 1 | -538.964 | 0.262467 | 231 | 57462.7 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 228.637 | 523 | 0 | 30680
633208 | Level 1 | -538.964 | 0.262467 | 236 | 1412805 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 5621.37 | 524 | 0 | 30680
633287 | Level 1 | -551.13 | 0.328084 | 234 | 70672.3 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 224.957 | 525 | 0 | 40260
633437 | Level 1 | -551.13 | 0.328084 | 242 | 786137 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 2502.35 | 529 | 0 | 40260
633526 | Level 1 | -551.13 | 0.328084 | 239 | 361752 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 1151.49 | 532 | 0 | 40260
633604 | Level 1 | -551.13 | 0.328084 | 589 | 1315429 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 4187.14 | 533 | 0 | 40260
633633 | Level 1 | -551.13 | 0.328084 | 20 | 52231.4 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 166.258 | 534 | 1 | 40260
633748 | Level 1 | -551.13 | 0.328084 | 244 | 631298 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 2009.48 | 536 | 0 | 40260
633886 | Level 1 | -551.13 | 0.328084 | 246 | 1039720 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 3309.53 | 538 | 0 | 40260
634188 | Level 1 | -551.13 | 0.328084 | 252 | 310745 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 989.133 | 542 | 0 | 40260
634230 | Level 1 | 271.65 | 0.164042 | 254 | 407000 | 50 mmø | Level: Level 1 |  | 271.65 | 2862.69 | 0.197917 | 0.17225 | 2591.04 | 543 | 0 | 20670
634239 | Level 1 | -466.663 | 0.164042 | 257 | 103506 | 50 mmø | Level: Level 1 |  | -466.663 | 192.275 | 0.197917 | 0.17225 | 658.938 | 544 | 0 | 20670
634426 | Level 1 | 52.3875 | 0.262467 | 39 | 33805.4 | 80 mmø | Level: Level 1 |  | 186.895 | 52.3875 | 0.291667 | 0.255667 | 134.507 | 550 | 4 | 30680
634441 | Level 1 | -51.1302 | 0.328084 | 568 | 72551 | 100 mmø | Level: Level 1 | 0 | 0 | 0 | 0.375 | 0.3355 | 230.937 | 551 | 0 | 40260
634445 | Level 1 | -26.2509 | 0.164042 | 263 | 35311.7 | 50 mmø | Level: Level 1 | 0 | 0 | 0 | 0.197917 | 0.17225 | 224.801 | 552 | 0 | 20670
634469 | Level 1 | -551.13 | 0.328084 | 264 | 101111 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 321.845 | 553 | 0 | 40260
634485 | Level 1 | -526.251 | 0.164042 | 433 | 3942.7 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 25.1 | 554 | 0 | 20670
634489 | Level 1 | -551.13 | 0.328084 | 265 | 977318 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 3110.9 | 555 | 0 | 40260
634602 | Level 1 | -51.1302 | 0.328084 | 434 | 4404.77 | 100 mmø |  | 0 | 0 | 0 | 0.375 | 0.3355 | 14.0208 | 556 | 0 | 40260
634653 | Level 1 | -551.13 | 0.328084 | 217 | 1545755 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 4920.29 | 558 | 0 | 40260
634780 | Level 1 | -551.13 | 0.328084 | 273 | 596849 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 1899.83 | 562 | 0 | 40260
634815 | Level 1 | -538.964 | 0.262467 | 277 | 151185 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 601.544 | 563 | 0 | 30680
635006 | Level 1 | -538.964 | 0.262467 | 278 | 596537 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 2373.55 | 567 | 0 | 30680
635041 | Level 1 | -538.964 | 0.262467 | 279 | 11508.5 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 45.7908 | 569 | 0 | 30680
635110 | Level 1 | -538.964 | 0.262467 | 281 | 139645 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 555.628 | 570 | 0 | 30680
635301 | Level 1 | -538.964 | 0.262467 | 284 | 470478 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 1871.97 | 576 | 0 | 30680
635330 | Level 1 | -526.251 | 0.164042 | 846 | 129854 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 826.675 | 578 | 0 | 20670
635820 | Level 1 | -551.13 | 0.328084 | 299 | 312437 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 994.518 | 587 | 0 | 40260
635854 | Level 1 | -526.251 | 0.164042 | 301 | 91215.3 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 580.694 | 588 | 0 | 20670
635968 | Level 1 | 181.802 | 0.328084 | 12 | 18977.6 | 100 mmø | Level: Level 1 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 60.4077 | 590 | 4 | 40260
635976 | Level 1 | -441.263 | 0.328084 | 8 | 23931.1 | 100 mmø | Level: Level 1 |  | -365.088 | -441.263 | 0.375 | 0.3355 | 76.175 | 591 | 9 | 40260
635999 | Level 1 | -234.913 | 0.328084 | 13 | 126530 | 100 mmø | Level: Level 1 |  | 167.845 | -234.913 | 0.375 | 0.3355 | 402.757 | 592 | 8 | 40260
636053 | Level 1 | -551.13 | 0.328084 | 305 | 972335 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 3095.04 | 594 | 0 | 40260
636090 | Level 1 | -551.13 | 0.328084 | 307 | 1380917 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 4395.59 | 595 | 0 | 40260
636097 | Level 1 | -551.13 | 0.328084 | 308 | 2435620 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 7752.82 | 596 | 0 | 40260
636215 | Level 1 | -526.251 | 0.164042 | 400 | 11868.4 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 75.5564 | 597 | 0 | 20670
636334 | Level 1 | -538.964 | 0.262467 | 208 | 49562.7 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 197.204 | 599 | 2 | 30680
636341 | Level 1 | -538.964 | 0.262467 | 311 | 243549 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 969.049 | 600 | 0 | 30680
636409 | Level 1 | -526.251 | 0.164042 | 394 | 35133.1 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 223.664 | 601 | 0 | 20670
636419 | Level 1 | -538.964 | 0.262467 | 313 | 927581 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 3690.73 | 602 | 0 | 30680
636546 | Level 1 | -526.251 | 0.164042 | 449 | 23387.1 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 148.887 | 603 | 0 | 20670
636558 | Level 1 | -538.964 | 0.262467 | 317 | 768824 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 3059.05 | 604 | 0 | 30680
636656 | Level 1 | -476.188 | 0.104987 | 87 | 119550 | 32 mmø | Level: Level 1 |  | 713 | -476.187 | 0.138333 | 0.115 | 1189.19 | 605 | 1 | 13800
636657 | Level 1 | -517.526 | 0.104987 | 87 | 8441.31 | 32 mmø | Level: Level 1 | 0 | -500 | -500 | 0.138333 | 0.115 | 83.9673 | 606 | 1 | 13800
636660 | Level 1 | -526.251 | 0.164042 | 453 | 18242.7 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 116.137 | 607 | 0 | 20670
636667 | Level 1 | -526.251 | 0.164042 | 319 | 45412.8 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 289.107 | 608 | 0 | 20670
636809 | Level 1 | -551.13 | 0.328084 | 325 | 768817 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 2447.22 | 612 | 0 | 40260
636815 | Level 1 | -551.13 | 0.328084 | 323 | 263677 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 839.309 | 613 | 0 | 40260
636883 | Level 1 | -551.13 | 0.328084 | 326 | 1494552 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 4757.31 | 615 | 0 | 40260
636973 | Level 1 | -551.13 | 0.328084 | 458 | 95117.5 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 302.768 | 616 | 0 | 40260
637032 | Level 1 | -551.13 | 0.328084 | 329 | 87475 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 278.442 | 619 | 0 | 40260
637197 | Level 1 | -551.983 | 0.328084 | 69 | 613339 | 100 mmø | Level: Level 1 | 0.0110096 | -479.363 | -500.856 | 0.375 | 0.3355 | 1952.32 | 621 | 4 | 40260
637267 | Level 1 | -552.254 | 0.328084 | 332 | 40329.9 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 128.374 | 623 | 0 | 40260
637394 | Level 1 | -552.254 | 0.328084 | 334 | 324649 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 1033.39 | 624 | 0 | 40260
637405 | Level 1 | -540.087 | 0.262467 | 336 | 151073 | 80 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.291667 | 0.255667 | 601.102 | 625 | 0 | 30680
637426 | Level 1 | -540.087 | 0.262467 | 337 | 98553.6 | 80 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.291667 | 0.255667 | 392.132 | 626 | 0 | 30680
637527 | Level 1 | -552.254 | 0.328084 | 338 | 306679 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 976.188 | 628 | 0 | 40260
637567 | Level 1 | -552.254 | 0.328084 | 340 | 741429 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 2360.04 | 629 | 0 | 40260
637628 | Level 1 | -552.254 | 0.328084 | 520 | 99497.2 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 316.709 | 631 | 0 | 40260
637709 | Level 1 | -552.254 | 0.328084 | 344 | 343346 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 1092.9 | 633 | 0 | 40260
637806 | Level 1 | 39.6875 | 0.164042 | 144 | 74299.6 | 50 mmø | Level: Level 1 |  | 39.6875 | 512.694 | 0.197917 | 0.17225 | 473.006 | 635 | 2 | 20670
637810 | Level 1 | -467.786 | 0.164042 | 145 | 67245.5 | 50 mmø | Level: Level 1 |  | -467.786 | -39.6875 | 0.197917 | 0.17225 | 428.098 | 636 | 4 | 20670
637860 | Level 1 | -552.254 | 0.328084 | 347 | 687482 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 2188.32 | 637 | 0 | 40260
637908 | Level 1 | -552.254 | 0.328084 | 348 | 299906 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 954.63 | 640 | 0 | 40260
638092 | Level 1 | -552.254 | 0.328084 | 350 | 70464.1 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 224.294 | 641 | 0 | 40260
638171 | Level 1 | -552.254 | 0.328084 | 57 | 159594 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 508.004 | 645 | 4 | 40260
639008 | Level 1 | -527.374 | 0.164042 | 504 | 18120.9 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 115.361 | 651 | 0 | 20670
639015 | Level 1 | -527.374 | 0.164042 | 353 | 151040 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 961.553 | 652 | 0 | 20670
639083 | Level 1 | 373.749 | 0.164042 | 137 | 21707.7 | 50 mmø | Level: Level 1 | 0 | 400 | 400 | 0.197917 | 0.17225 | 138.196 | 655 | 2 | 20670
639088 | Level 1 | 423.812 | 0.104987 | 136 | 18845.8 | 32 mmø | Level: Level 1 |  | 423.812 | 611.275 | 0.138333 | 0.115 | 187.463 | 656 | 2 | 13800
639178 | Level 1 | 452.387 | 0.262467 | 356 | 11966.3 | 80 mmø | Level: Level 1 |  | 452.387 | 500 | 0.291667 | 0.255667 | 47.6125 | 658 | 0 | 30680
639185 | Level 1 | -447.942 | 0.262467 | 355 | 199945 | 80 mmø | Level: Level 1 |  | -447.942 | 347.612 | 0.291667 | 0.255667 | 795.555 | 659 | 0 | 30680
639206 | Level 1 | -518.649 | 0.104987 | 140 | 24091.4 | 32 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.138333 | 0.115 | 239.641 | 660 | 2 | 13800
639213 | Level 1 | -477.311 | 0.104987 | 140 | 109437 | 32 mmø | Level: Level 1 |  | -477.311 | 611.275 | 0.138333 | 0.115 | 1088.59 | 661 | 2 | 13800
639217 | Level 1 | -527.374 | 0.164042 | 354 | 36096.6 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 229.798 | 662 | 0 | 20670
639341 | Level 1 | -527.374 | 0.164042 | 358 | 521923 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 3322.66 | 665 | 0 | 20670
639406 | Level 1 | -552.254 | 0.328084 | 360 | 551000 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 1753.89 | 666 | 0 | 40260
639471 | Level 1 | -552.254 | 0.328084 | 362 | 333294 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 1060.91 | 668 | 0 | 40260
639591 | Level 1 | -552.254 | 0.328084 | 365 | 790736 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 2516.99 | 672 | 0 | 40260
639719 | Level 1 | -552.254 | 0.328084 | 372 | 157619 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 501.715 | 674 | 0 | 40260
639727 | Level 1 | -552.254 | 0.328084 | 371 | 342363 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 1089.78 | 675 | 0 | 40260
639847 | Level 1 | -552.254 | 0.328084 | 373 | 211597 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 673.534 | 678 | 0 | 40260
639861 | Level 1 | -552.254 | 0.328084 | 374 | 1991665 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 6339.67 | 679 | 0 | 40260
639933 | Level 1 | -51.1302 | 0.328084 | 376 | 13895.7 | 100 mmø | Level: Level 1 | 0 | 0 | 0 | 0.375 | 0.3355 | 44.2312 | 680 | 0 | 40260
640075 | Level 1 | -551.13 | 0.328084 | 380 | 61057.7 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 194.353 | 683 | 0 | 40260
640084 | Level 1 | -551.13 | 0.328084 | 377 | 8793.18 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 27.9896 | 684 | 0 | 40260
640316 | Level 1 | -434.913 | 0.328084 | 74 | 191357 | 100 mmø | Level: Level 1 |  | -434.912 | 174.195 | 0.375 | 0.3355 | 609.107 | 685 | 4 | 40260
640318 | Level 1 | -551.13 | 0.328084 | 488 | 993.47 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 3.16231 | 686 | 0 | 40260
640389 | Level 1 | -551.13 | 0.328084 | 718 | 56924.1 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 181.195 | 688 | 0 | 40260
640414 | Level 1 | -551.13 | 0.328084 | 499 | 19470.3 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 61.9758 | 689 | 0 | 40260
640547 | Level 1 | -551.13 | 0.328084 | 383 | 153523 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 488.678 | 693 | 0 | 40260
640618 | Level 1 | -551.13 | 0.328084 | 387 | 1106719 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 3522.8 | 694 | 0 | 40260
640627 | Level 1 | -551.13 | 0.328084 | 388 | 455725 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 1450.62 | 695 | 0 | 40260
640675 | Level 1 | -551.13 | 0.328084 | 533 | 236276 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 752.091 | 696 | 0 | 40260
640680 | Level 1 | -551.13 | 0.328084 | 391 | 654474 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 2083.25 | 697 | 0 | 40260
640712 | Level 1 | -551.13 | 0.328084 | 392 | 359880 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 1145.53 | 698 | 0 | 40260
641006 | Level 1 | -551.13 | 0.328084 | 718 | 47654.5 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 151.689 | 699 | 0 | 40260
641065 | Level 1 | -551.13 | 0.328084 | 381 | 48861.8 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 155.532 | 700 | 0 | 40260
641152 | Level 1 | -526.251 | 0.164042 | 394 | 209299 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 1332.44 | 706 | 0 | 20670
641194 | Level 1 | -517.526 | 0.104987 | 399 | 356.594 | 32 mmø | Level: Level 1 | 0 | -500 | -500 | 0.138333 | 0.115 | 3.54711 | 710 | 0 | 13800
641236 | Level 1 | -526.251 | 0.164042 | 400 | 339004 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 2158.17 | 714 | 0 | 20670
641262 | Level 1 | -538.964 | 0.262467 | 310 | 992032 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 3947.17 | 719 | 0 | 30680
641363 | Level 2 | -526.251 | 0.164042 | 408 | 153345 | 50 mmø | Level: Level 2 | 0 | -5070 | -5070 | 0.197917 | 0.17225 | 976.223 | 724 | 0 | 20670
641449 | Level 1 | -551.13 | 0.328084 | 306 | 3449212 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 10979.2 | 725 | 0 | 40260
641593 | Level 1 | -526.251 | 0.164042 | 416 | 11079.3 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 70.5333 | 728 | 0 | 20670
641600 | Level 1 | -538.964 | 0.262467 | 414 | 1100655 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 4379.37 | 729 | 0 | 30680
641604 | Level 1 | -526.251 | 0.164042 | 157 | 27209.9 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 173.224 | 730 | 2 | 20670
641609 | Level 1 | -526.251 | 0.164042 | 157 | 49554.7 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 315.475 | 731 | 2 | 20670
641615 | Level 1 | -476.188 | 0.104987 | 156 | 108190 | 32 mmø | Level: Level 1 |  | -476.188 | 600 | 0.138333 | 0.115 | 1076.19 | 732 | 2 | 13800
641636 | Level 1 | -526.251 | 0.164042 | 416 | 556979 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 3545.84 | 736 | 0 | 20670
641978 | Level 1 | -526.251 | 0.164042 | 248 | 219900 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 1399.92 | 749 | 0 | 20670
642086 | Level 1 | -551.13 | 0.328084 | 423 | 18992.6 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 60.4552 | 758 | 0 | 40260
642163 | Level 1 | -517.526 | 0.104987 | 179 | 28698.5 | 32 mmø | Level: Level 1 | 0 | -500 | -500 | 0.138333 | 0.115 | 285.469 | 763 | 2 | 13800
642171 | Level 1 | -551.13 | 0.328084 | 427 | 826940 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 2632.23 | 764 | 0 | 40260
642336 | Level 1 | -551.13 | 0.328084 | 8 | 32051.6 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 102.023 | 771 | 9 | 40260
642460 | Level 1 | -551.13 | 0.328084 | 18 | 160086 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 509.571 | 778 | 5 | 40260
642630 | Level 1 | -551.13 | 0.328084 | 431 | 543979 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 1731.54 | 785 | 0 | 40260
642725 | Level 1 | -526.251 | 0.164042 | 433 | 3208 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 20.4228 | 790 | 0 | 20670
642804 | Level 1 | -51.1302 | 0.328084 | 30 | 144736 | 100 mmø | Level: Level 1 | 0 | 0 | 0 | 0.375 | 0.3355 | 460.71 | 796 | 1 | 40260
643057 | Level 1 | -526.251 | 0.164042 | 438 | 17832.1 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 113.523 | 802 | 0 | 20670
643064 | Level 1 | -551.13 | 0.328084 | 436 | 1013628 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 3226.48 | 803 | 0 | 40260
643068 | Level 1 | -526.251 | 0.164042 | 90 | 4290.93 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 27.3169 | 804 | 1 | 20670
643187 | Level 1 | -526.251 | 0.164042 | 90 | 28265.9 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 179.946 | 805 | 1 | 20670
643195 | Level 1 | -476.188 | 0.104987 | 89 | 119550 | 32 mmø | Level: Level 1 |  | 713 | -476.188 | 0.138333 | 0.115 | 1189.19 | 806 | 1 | 13800
643200 | Level 1 | -526.251 | 0.164042 | 440 | 113260 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 721.038 | 807 | 0 | 20670
643207 | Level 1 | -526.251 | 0.164042 | 438 | 520443 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 3313.24 | 808 | 0 | 20670
643210 | Level 1 | -526.251 | 0.164042 | 441 | 403170 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 2566.66 | 809 | 0 | 20670
643225 | Level 1 | -526.251 | 0.164042 | 442 | 24201.8 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 154.074 | 810 | 0 | 20670
643232 | Level 1 | -526.251 | 0.164042 | 447 | 167059 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 1063.53 | 811 | 0 | 20670
643234 | Level 1 | -526.251 | 0.164042 | 442 | 188073 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 1197.31 | 812 | 0 | 20670
643290 | Level 1 | -466.663 | 0.164042 | 442 | 696385 | 50 mmø | Level: Level 1 |  | -466.663 | 3966.66 | 0.197917 | 0.17225 | 4433.33 | 814 | 0 | 20670
643342 | Level 1 | -466.663 | 0.164042 | 441 | 523597 | 50 mmø | Level: Level 1 |  | -466.663 | 2866.66 | 0.197917 | 0.17225 | 3333.33 | 816 | 0 | 20670
643372 | Level 1 | -526.251 | 0.164042 | 439 | 78087.2 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 497.119 | 819 | 0 | 20670
643553 | Level 1 | -526.251 | 0.164042 | 448 | 34720.5 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 221.038 | 826 | 0 | 20670
643560 | Level 1 | -526.251 | 0.164042 | 440 | 195583 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 1245.12 | 827 | 0 | 20670
643562 | Level 1 | -526.251 | 0.164042 | 448 | 249158 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 1586.19 | 828 | 0 | 20670
643588 | Level 1 | -526.251 | 0.164042 | 449 | 283556 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 1805.18 | 831 | 0 | 20670
643619 | Level 1 | -526.251 | 0.164042 | 452 | 292612 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 1862.82 | 835 | 0 | 20670
644090 | Level 1 | -551.13 | 0.328084 | 811 | 1618663 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 5152.36 | 854 | 0 | 40260
644184 | Level 1 | -526.251 | 0.164042 | 459 | 394806 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 2513.41 | 862 | 0 | 20670
644197 | Level 1 | -552.254 | 0.328084 | 464 | 305494 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 972.418 | 864 | 0 | 40260
644204 | Level 1 | -552.254 | 0.328084 | 71 | 139775 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 444.916 | 865 | 2 | 40260
644498 | Level 1 | 181.802 | 0.328084 | 68 | 57751.6 | 100 mmø | Level: Level 1 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 183.829 | 871 | 4 | 40260
644756 | Level 1 | 261.036 | 0.262467 | 466 | 14030.1 | 80 mmø | Level: Level 1 | 0 | 300 | 300 | 0.291667 | 0.255667 | 55.824 | 876 | 0 | 30680
644782 | Level 1 | -552.254 | 0.328084 | 470 | 63663.2 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 202.646 | 880 | 0 | 40260
644846 | Level 1 | -518.649 | 0.104987 | 62 | 21192.6 | 32 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.138333 | 0.115 | 210.806 | 883 | 1 | 13800
644909 | Level 1 | 181.802 | 0.328084 | 61 | 14109.7 | 100 mmø | Level: Level 1 | 0 | 232.932 | 232.932 | 0.375 | 0.3355 | 44.9125 | 885 | 4 | 40260
644937 | Level 1 | -527.374 | 0.164042 | 475 | 302045 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 1922.88 | 888 | 0 | 20670
645355 | Level 1 | -552.254 | 0.328084 | 478 | 63735.4 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 202.876 | 900 | 0 | 40260
645542 | Level 1 | -527.374 | 0.164042 | 145 | 7032.53 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 44.7704 | 909 | 4 | 20670
645699 | Level 1 | -527.374 | 0.164042 | 484 | 31340.3 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 199.519 | 913 | 0 | 20670
645706 | Level 1 | -527.374 | 0.164042 | 483 | 875852 | 50 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.197917 | 0.17225 | 5575.84 | 914 | 0 | 20670
645814 | Level 1 | -538.964 | 0.262467 | 386 | 241007 | 80 mmø | Level: Level 1 | 0 | -500 | -500 | 0.291667 | 0.255667 | 958.935 | 922 | 0 | 30680
645840 | Level 1 | -551.13 | 0.328084 | 495 | 257898 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 820.915 | 925 | 0 | 40260
645867 | Level 1 | -551.13 | 0.328084 | 495 | 993.47 | 100 mmø | Level: Level 1 | 0 | -500 | -500 | 0.375 | 0.3355 | 3.16231 | 930 | 0 | 40260
645954 | Level 1 | -526.251 | 0.164042 | 493 | 48177.3 | 50 mmø | Level: Level 1 | 0 | -500 | -500 | 0.197917 | 0.17225 | 306.707 | 935 | 0 | 20670
