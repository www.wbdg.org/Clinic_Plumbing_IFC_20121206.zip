Properties of the parts of a building model (IFC2X3), part 20 of 29

# IfcFlowSegment: Pipe Types:Cold Water:677372 (822)
Name (Pipe Types:Cold Water:...) | In | Friction Factor | Reynolds Number | Flow State | Pressure Drop | Velocity | Flow | Fixture Units | Relative Roughness | Friction | Mark | Area (mm2) | Schedule/Type | Roughness | Material | Pipe Segment | Diameter | Section | Invert Elevation (mm) | System Name | End Offset (mm) | Start Offset (mm) = Offset (mm) | Reference Level | Slope | Outer Diameter | Size = Overall Size | Inner Diameter | Length (mm)
690251 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2197 | 13453 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 126 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 285.482
690272 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2199 | 59846.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 481 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 952.488
690273 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2200 | 92053.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 698 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 1465.08
690278 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2201 | 22778.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 698 | 491.895 | Domestic Cold Water 1 | 500 | 500 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 362.538
690311 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2202 | 61434 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 698 | -495.216 | Domestic Cold Water 1 | 482.538 | -495.216 | Level: Level 1 |  | 0.0625 | 20 mmø | 0.0531824 | 977.753
690361 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2203 | 57697.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 484 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 918.284
690424 | Level 1 | 0.0142324 | 100715 | 2 | 71747.2 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 2204 | 147950 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 69 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 3139.6
690431 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2205 | 222270 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 487 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 2830.03
690462 | Level 1 | 0.0142324 | 100715 | 2 | 19187.5 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 2207 | 39566.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 69 | -498.391 | Domestic Cold Water 1 | 341.238 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 839.628
690483 | Level 1 | 0.0142324 | 100715 | 2 | 6101.49 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 2208 | 12581.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 71 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 266.996
690504 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2210 | 389216 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 480 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 4955.65
690508 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2211 | 160498 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 129 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 3405.87
690547 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2213 | 40308.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 129 | -498.391 | Domestic Cold Water 1 | 356.975 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 855.366
690570 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2214 | 19446.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 129 | 385.549 | Domestic Cold Water 1 | 798.223 | 385.55 | Level: Level 1 | 4100.48 | 0.0416667 | 15 mmø | 0.0349738 | 412.673
690571 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2215 | 3932.15 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 129 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 83.4428
690575 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2216 | 1039.78 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 129 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 22.0649
690660 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2218 | 73165.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 488 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 582.233
690761 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2219 | 234492 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 217 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 1866.03
690809 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2221 | 172848 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 217 | -485.691 | Domestic Cold Water 1 | 889.794 | -485.691 | Level: Level 1 |  | 0.125 | 40 mmø | 0.114304 | 1375.48
690837 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2222 | 1800.72 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 216 | 909.07 | Domestic Cold Water 1 | 914.4 | 914.4 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 38.2125
690844 | Level 1 | 0.0112912 | 55468.5 | 2 | 248.828 | 5.86225 | 0.0601563 | 10 | 13716.5 | 48.0116 | 2223 | 198508 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 18 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 1579.68
690851 | Level 1 | 0.0112912 | 55468.5 | 2 | 254.304 | 5.86225 | 0.0601563 | 10 | 13716.5 | 48.0116 | 2224 | 202876 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 19 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 1614.44
690891 | Level 1 | 0.0112912 | 55468.5 | 2 | 180.04 | 5.86225 | 0.0601563 | 10 | 13716.5 | 48.0116 | 2226 | 143631 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 18 | -485.691 | Domestic Cold Water 1 | 657.288 | -485.691 | Level: Level 1 |  | 0.125 | 40 mmø | 0.114304 | 1142.98
690910 | Level 1 | 0.0122545 | 85661.5 | 2 | 167.41 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 2227 | 8755.61 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 17 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 111.48
690911 | Level 1 | 0.0122545 | 85661.5 | 2 | 318.743 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 2228 | 16670.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 17 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 212.254
690933 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2229 | 129887 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 496 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 1653.77
690942 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 2230 | 187120 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 294 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 916.343
690946 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2231 | 29262.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 188 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 465.731
690998 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2232 | 192273 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 187 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 4080.16
691015 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2233 | 91958.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 187 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1951.43
691051 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2235 | 40308.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 187 | -498.391 | Domestic Cold Water 1 | 356.975 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 855.366
691074 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2236 | 19446.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 187 | 385.55 | Domestic Cold Water 1 | 798.223 | 385.553 | Level: Level 1 | 2146.57 | 0.0416667 | 15 mmø | 0.0349738 | 412.671
691075 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2237 | 8499.99 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 187 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 180.375
691078 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2238 | 3437.02 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 187 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 72.9359
691087 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2239 | 91248 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 181 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1936.34
691092 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2240 | 151911 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 684 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 2417.73
691133 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2242 | 40308.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 181 | -498.391 | Domestic Cold Water 1 | 356.975 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 855.366
691170 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2243 | 19446.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 181 | 385.55 | Domestic Cold Water 1 | 798.223 | 385.553 | Level: Level 1 | 2146.57 | 0.0416667 | 15 mmø | 0.0349738 | 412.671
691171 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2244 | 8499.99 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 181 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 180.375
691174 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2245 | 2699.34 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 181 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 57.2817
691183 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2246 | 103500 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 495 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 2196.34
691188 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2247 | 98668.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 492 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 1570.36
691234 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2249 | 40308.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 495 | -498.391 | Domestic Cold Water 1 | 356.975 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 855.366
691259 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2252 | 11531.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 495 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 244.708
691268 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2253 | 57520.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 497 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 732.375
691275 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2254 | 238873 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 498 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 3041.43
691277 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2255 | 9374.71 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 497 | 188.72 | Domestic Cold Water 1 | 200 | 200 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 119.363
691315 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2256 | 52731.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 497 | -492.041 | Domestic Cold Water 1 | 179.363 | -492.041 | Level: Level 1 |  | 0.0833333 | 25 mmø | 0.0740157 | 671.403
691325 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2257 | 149101 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 500 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 3164.01
691332 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2258 | 68461 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 502 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 871.672
691336 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2259 | 31640.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 500 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 671.425
691375 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2261 | 40308.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 500 | -498.391 | Domestic Cold Water 1 | 356.975 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 855.366
691400 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2264 | 2719.03 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 500 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 57.6997
691434 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2265 | 54730 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 491 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 696.844
691511 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2267 | 158472 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 405 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 1008.86
691576 | Level 1 | 0.0106702 | 22583.6 | 2 | 7.83852 | 1.74916 | 0.0334201 | 2.25 | 18716.5 | 2.96026 | 2269 | 126777 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 80 | -479.341 | Domestic Cold Water 1 | 327.744 | -479.341 | Level: Level 1 |  | 0.166667 | 50 mmø | 0.155971 | 807.084
691890 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2270 | 77316.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 504 | 3046.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 492.213
691897 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2271 | 134613 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 503 | 3109.69 | Domestic Cold Water 1 | 3966.66 | 3109.69 | Level: Level 1 |  | 0.166667 | 50 mmø | 0.155971 | 856.975
691916 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2272 | 551295 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 318 | -479.341 | Domestic Cold Water 1 | 3030.31 | -479.341 | Level: Level 1 |  | 0.166667 | 50 mmø | 0.155971 | 3509.65
691918 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2273 | 136184 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 504 | 3046.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 866.975
691936 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2275 | 745604 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 505 | 3046.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 4746.66
691994 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2276 | 289770 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 517 | 3046.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 1844.74
692042 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2277 | 65718.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 517 | 3046.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 418.375
692148 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2279 | 256562 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 517 | 3103.34 | Domestic Cold Water 1 | 166.663 | -1466.66 | Level: Level 2 |  | 0.166667 | 50 mmø | 0.155971 | 1633.33
692181 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2284 | 5644.41 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 508 | 4764.67 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 119.778
692184 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2285 | 98858 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 511 | 4746.23 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 629.35
692202 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2288 | 10905.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 513 | 4764.67 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 231.417
692211 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2290 | 3491.09 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 509 | 4746.23 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 22.225
692429 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2300 | 118599 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 514 | 4746.23 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 755.022
692435 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2301 | 48350.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 517 | 4746.23 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 307.809
692534 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2302 | 15228.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 517 | 3046.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 96.9502
692574 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2303 | 20382.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 519 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 432.531
692581 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2304 | 61137.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 505 | 3046.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 389.214
692585 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2305 | 214020 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 690 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 4541.64
692594 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2306 | 3096.63 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 690 | 4764.67 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 65.7125
692653 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2307 | 78764 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 690 | 3084.29 | Domestic Cold Water 1 | 185.713 | -1485.71 | Level: Level 2 |  | 0.0416667 | 15 mmø | 0.0349738 | 1671.43
692673 | Level 2 | 0.0106702 | 22583.6 | 2 | 13.0371 | 1.74916 | 0.0334201 | 2.25 | 18716.5 | 2.96026 | 2308 | 210855 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 74 | 3046.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 1342.35
692679 | Level 2 | 0.0106702 | 22583.6 | 2 | 0.960349 | 1.74916 | 0.0334201 | 2.25 | 18716.5 | 2.96026 | 2309 | 15532.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 74 | 3046.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 98.8812
692684 | Level 2 | 0.0142324 | 100715 | 2 | 70210.3 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 2310 | 144781 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 73 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 3072.34
692781 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2313 | 70678 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 520 | 3046.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 449.95
692788 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2314 | 403128 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 524 | 3046.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 2566.39
692789 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2315 | 81214.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 522 | 4746.23 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 517.028
692847 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2316 | 256562 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 520 | 3103.34 | Domestic Cold Water 1 | 166.663 | -1466.66 | Level: Level 2 |  | 0.166667 | 50 mmø | 0.155971 | 1633.33
692930 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2317 | 5826.72 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 522 | 4746.23 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 37.0941
692969 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2322 | 5712.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 776 | 4764.67 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 121.232
692980 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2324 | 351375 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 520 | 4746.23 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 2236.92
692989 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2325 | 94094.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 520 | 3046.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 599.025
693001 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2326 | 124920 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 692 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 1988.17
693007 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2327 | 192431 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 506 | 3046.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 1225.06
693011 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2328 | 60637.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 692 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 965.075
693018 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2329 | 39902.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 692 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 635.075
693023 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2330 | 6442.62 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 692 | 4761.9 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 102.538
693059 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2331 | 104620 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 692 | 3087.46 | Domestic Cold Water 1 | 182.538 | -1482.54 | Level: Level 2 |  | 0.0625 | 20 mmø | 0.0531824 | 1665.08
693076 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 2332 | 137028 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 528 | -561.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.333333 | 100 mmø | 0.320013 | 436.175
693081 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 2333 | 453623 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 337 | -561.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.333333 | 100 mmø | 0.320013 | 1443.93
693082 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 2334 | 183006 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 528 | -561.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.333333 | 100 mmø | 0.320013 | 582.525
693091 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 2335 | 184751 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 528 | 3021.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.333333 | 100 mmø | 0.320013 | 588.081
693116 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 2336 | 1088626 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 528 | -453.941 | Domestic Cold Water 1 | 3011.26 | -453.941 | Level: Level 1 |  | 0.333333 | 100 mmø | 0.320013 | 3465.2
693246 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2337 | 241358 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 529 | 3052.58 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.125 | 40 mmø | 0.114304 | 1920.67
693257 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2338 | 441088 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 534 | 3052.58 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.125 | 40 mmø | 0.114304 | 3510.07
693363 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2340 | 218614 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 534 | 3096.99 | Domestic Cold Water 1 | 266.663 | -1473.01 | Level: Level 2 |  | 0.125 | 40 mmø | 0.114304 | 1739.68
693367 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2341 | 19676.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 531 | 4852.58 | Domestic Cold Water 1 | 300 | 300 | Level: Level 2 | 0 | 0.125 | 40 mmø | 0.114304 | 156.58
693446 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2342 | 3927.78 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 530 | 4852.58 | Domestic Cold Water 1 | 300 | 300 | Level: Level 2 | 0 | 0.125 | 40 mmø | 0.114304 | 31.2563
693449 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2343 | 69592.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 531 | 4852.58 | Domestic Cold Water 1 | 300 | 300 | Level: Level 2 | 0 | 0.125 | 40 mmø | 0.114304 | 553.797
693498 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2345 | 663.801 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 775 | 4864.67 | Domestic Cold Water 1 | 300 | 300 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 14.0863
693701 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2349 | 39170.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 529 | 3052.58 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.125 | 40 mmø | 0.114304 | 311.708
693928 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2350 | 93179.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 699 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 1483
693982 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2351 | 44785.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 535 | 3058.72 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 570.223
693998 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 11216.5 | 0 | 2352 | 17315.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.104987 | 536 | 3055.76 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.104167 | 32 mmø | 0.0934711 | 172.238
694054 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2354 | 23387.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 656 | 3058.72 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 297.782
694092 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2355 | 179203 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 540 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 2852.1
694118 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2356 | 64215.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 540 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 1022.02
694245 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2362 | 18703.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 538 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 297.671
694259 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2363 | 96652.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 545 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 1538.27
694292 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2365 | 404599 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 546 | 3058.72 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 5151.51
694297 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2366 | 45641.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 545 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 726.41
694486 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2368 | 15546.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 545 | 4861.9 | Domestic Cold Water 1 | 300 | 300 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 247.425
694493 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2369 | 110903 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 545 | 3087.46 | Domestic Cold Water 1 | 282.538 | -1482.54 | Level: Level 2 |  | 0.0625 | 20 mmø | 0.0531824 | 1765.08
694545 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2372 | 8158.14 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 543 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 129.841
694568 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2373 | 189406 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 550 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 4019.32
694575 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2374 | 198025 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 537 | 3058.72 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 2521.33
694770 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2380 | 34271.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 548 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 727.269
694812 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2381 | 96772.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 555 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 1540.18
694823 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2383 | 37862.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 555 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 602.598
694966 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2388 | 9493.16 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 553 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 151.088
694988 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2389 | 89389.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 563 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1896.91
694995 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 2390 | 713442 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 556 | 3039.88 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.208333 | 65 mmø | 0.197638 | 3493.78
694999 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2391 | 29131.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 563 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 618.195
695091 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2398 | 83951.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 565 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1781.51
695098 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 2399 | 170461 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 559 | 3039.88 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.208333 | 65 mmø | 0.197638 | 834.761
695102 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2400 | 23491.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 565 | 4664.67 | Domestic Cold Water 1 | 100 | 100 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 498.512
695195 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2405 | 6210.43 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 558 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 131.789
695216 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2406 | 5301 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 561 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 112.491
695241 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2407 | 84921 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 570 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1802.08
695251 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 11216.5 | 0 | 2408 | 227329 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.104987 | 566 | 3055.76 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.104167 | 32 mmø | 0.0934711 | 2261.28
695256 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2409 | 44899.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 570 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 952.797
695345 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2415 | 6423.13 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 568 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 136.303
695367 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2416 | 347395 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 575 | 3046.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 2211.59
695375 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 11216.5 | 0 | 2417 | 104991 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.104987 | 574 | 3055.76 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.104167 | 32 mmø | 0.0934711 | 1044.36
695379 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2418 | 73555 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 575 | 3046.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 468.266
695384 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2419 | 324631 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 575 | 3046.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 2066.66
695393 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2420 | 51787.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 777 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1098.97
695423 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2421 | 3491.85 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 777 | 4764.67 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 74.0993
695469 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2422 | 78764 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 777 | 3084.29 | Domestic Cold Water 1 | 185.713 | -1485.71 | Level: Level 2 |  | 0.0416667 | 15 mmø | 0.0349738 | 1671.43
695546 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2424 | 122340 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 572 | 3046.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 778.841
695610 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2425 | 299226 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 576 | 3046.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 1904.93
695621 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2426 | 114727 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 587 | 3046.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 730.375
695826 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2427 | 17513 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 585 | 4746.23 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 111.491
695849 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2430 | 20508.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 578 | 4746.23 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 130.562
695899 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2431 | 5889.63 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 578 | 4746.23 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 37.4945
695956 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2436 | 377038 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 578 | 4746.23 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 2400.3
696030 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2438 | 18937.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 579 | 5046.23 | Domestic Cold Water 1 | 500 | 500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 120.562
696035 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2439 | 35653.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 579 | 4809.69 | Domestic Cold Water 1 | 466.663 | 239.688 | Level: Level 2 |  | 0.166667 | 50 mmø | 0.155971 | 226.975
696037 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2440 | 161112 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 581 | 4746.23 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 1025.67
696041 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2441 | 3361.11 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 579 | 5046.23 | Domestic Cold Water 1 | 500 | 500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 21.3975
696076 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2444 | 19168.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 582 | 5046.23 | Domestic Cold Water 1 | 500 | 500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 122.03
696081 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2445 | 35653.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 582 | 4809.69 | Domestic Cold Water 1 | 466.663 | 239.688 | Level: Level 2 |  | 0.166667 | 50 mmø | 0.155971 | 226.975
696083 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2446 | 224405 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 585 | 4746.23 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 1428.61
696087 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2447 | 3504.38 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 582 | 5046.23 | Domestic Cold Water 1 | 500 | 500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 22.3096
696196 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2454 | 37875.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 584 | 5046.23 | Domestic Cold Water 1 | 500 | 500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 241.122
696320 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2457 | 35653.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 584 | 4809.69 | Domestic Cold Water 1 | 466.663 | 239.687 | Level: Level 2 |  | 0.166667 | 50 mmø | 0.155971 | 226.975
696323 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2458 | 255565 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 576 | 3103.34 | Domestic Cold Water 1 | 160.312 | -1466.66 | Level: Level 2 |  | 0.166667 | 50 mmø | 0.155971 | 1626.97
696357 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2459 | 28649.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 589 | 5064.67 | Domestic Cold Water 1 | 500 | 500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 607.966
696362 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2460 | 91068.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 589 | 3123.18 | Domestic Cold Water 1 | 485.713 | -1446.82 | Level: Level 2 |  | 0.0416667 | 15 mmø | 0.0349738 | 1932.53
696364 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2461 | 588958 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 572 | 3046.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 3749.42
696384 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2463 | 1678.79 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 589 | 5064.67 | Domestic Cold Water 1 | 500 | 500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 35.625
696406 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2464 | 415646 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 594 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 8820.28
696413 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2465 | 85564.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 590 | 3058.72 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 1089.44
696417 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2466 | 51561.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 594 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1094.16
696457 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2468 | 92602 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 594 | 3084.29 | Domestic Cold Water 1 | 479.362 | -1485.71 | Level: Level 2 |  | 0.0416667 | 15 mmø | 0.0349738 | 1965.07
696518 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2469 | 39410 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 592 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 836.307
696616 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2470 | 79534.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 599 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1687.78
696623 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2471 | 36540.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 595 | 3058.72 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 465.243
696627 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2472 | 67984 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 599 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1442.67
696729 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2476 | 2831.06 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 597 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 60.0769
696757 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2477 | 89524.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 604 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1899.77
696764 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2478 | 332565 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 600 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 5292.93
696768 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2479 | 57315.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 604 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1216.26
696845 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2483 | 5820.42 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 602 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 123.513
696860 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2484 | 129460 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 609 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 2747.22
696867 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2485 | 90387.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 605 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 1438.56
696871 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2486 | 24992.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 609 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 530.351
696963 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2490 | 35668 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 607 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 756.9
696977 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2491 | 76543.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 614 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1624.31
697026 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2493 | 171590 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 610 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 2730.94
697031 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2494 | 67000.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 614 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1421.8
697152 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2500 | 4437.95 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 612 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 94.1763
697166 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2501 | 68820.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 617 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1460.41
697174 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2502 | 2826.01 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 756 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 59.9697
697179 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2503 | 971.93 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 756 | 5064.67 | Domestic Cold Water 1 | 500 | 500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 20.625
697288 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2504 | 92901.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 756 | 3084.29 | Domestic Cold Water 1 | 485.713 | -1485.71 | Level: Level 2 |  | 0.0416667 | 15 mmø | 0.0349738 | 1971.43
697333 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2507 | 14303 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 615 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 303.52
697347 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2508 | 109461 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 695 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 2322.84
697354 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2509 | 35760.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 618 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 569.149
697358 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2510 | 32151.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 695 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 682.272
697399 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2514 | 219787 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 747 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 4664.03
697406 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 2515 | 22989.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 745 | 3039.88 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.208333 | 65 mmø | 0.197638 | 112.579
697456 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 2519 | 1111639 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 626 | 3039.88 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.208333 | 65 mmø | 0.197638 | 5443.78
697657 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 2530 | 256613 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 621 | 3039.88 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.208333 | 65 mmø | 0.197638 | 1256.65
697661 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 2531 | 401140 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 622 | 3039.88 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.208333 | 65 mmø | 0.197638 | 1964.41
697671 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2532 | 8785.86 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 625 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 139.831
697678 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 2533 | 303942 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 632 | 3039.88 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.208333 | 65 mmø | 0.197638 | 1488.42
697682 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2534 | 20786.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 697 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 330.821
697696 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2535 | 50093 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 780 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1063.01
697703 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 2536 | 383264 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 628 | 3039.88 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.208333 | 65 mmø | 0.197638 | 1876.87
697707 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2537 | 6747.06 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 780 | 5064.68 | Domestic Cold Water 1 | 500.005 | 500.005 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 143.177
697745 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2538 | 92901.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 780 | 3084.29 | Domestic Cold Water 1 | 485.718 | -1485.71 | Level: Level 2 |  | 0.0416667 | 15 mmø | 0.0349738 | 1971.43
697757 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2540 | 186997 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 648 | 3046.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 1190.46
697762 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 2541 | 230821 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 633 | 3039.88 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.208333 | 65 mmø | 0.197638 | 1130.35
697773 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2543 | 28635.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 644 | 3061.9 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0625 | 20 mmø | 0.0531824 | 455.75
697906 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 28401.6 | 0 | 2544 | 62154.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.262467 | 634 | 3033.93 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.25 | 80 mmø | 0.23668 | 247.305
697994 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 2546 | 4229.98 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 631 | 3039.88 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.208333 | 65 mmø | 0.197638 | 20.7145
698110 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2547 | 81748.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 630 | 3046.23 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.166667 | 50 mmø | 0.155971 | 520.43
698122 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2548 | 94530.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 778 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 2006.01
698136 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 28401.6 | 0 | 2549 | 593065 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.262467 | 449 | 3033.93 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.25 | 80 mmø | 0.23668 | 2359.73
698141 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2550 | 272820 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 778 | 3064.67 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 5789.43
698146 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2551 | 6393.33 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 778 | 4764.67 | Domestic Cold Water 1 | 200 | 200 | Level: Level 2 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 135.671
698215 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2552 | 78764 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 778 | 3084.29 | Domestic Cold Water 1 | 185.713 | -1485.71 | Level: Level 2 |  | 0.0416667 | 15 mmø | 0.0349738 | 1671.43
