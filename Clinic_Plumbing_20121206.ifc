Properties of the parts of a building model (IFC2X3), part 15 of 29

# IfcFlowFitting: Transition - Generic (1079)
Name (M_Transition - Generic:Transition - Generic:Transition - Generic:...) | In | Fitting Outside Radius 1 = Insulation Radius 1 | Width Offset | Visibility 3 | Visibility 1 | Max Fitting Outside Diameter 12 | Visibility 2 | Fitting Outside Radius 2 = Insulation Radius 2 | Height Offset | System Name | System Classification | System Type | Loss Method | Offset (mm) | Level | Host | Mark | Fitting Outside Diameter 2 | OffsetHeight | Length | Nominal Radius 1 | OffsetWidth | Nominal Radius 2 | Tick Size 2 | Tick Size 1 | Fitting Outside Diameter 1 | Size = Overall Size | Nominal Diameter 1 | Nominal Diameter 2
705416 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -250 | Level: Level 1 | Level : Level 1 | 8001 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
705551 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8017 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
705725 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -250 | Level: Level 1 | Level : Level 1 | 8031 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
705726 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -250 | Level: Level 1 | Level : Level 1 | 8032 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
705943 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -250 | Level: Level 1 | Level : Level 1 | 8050 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
705944 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -250 | Level: Level 1 | Level : Level 1 | 8051 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
705988 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.046875 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8052 | 0.09375 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0410105 | 0.0375 | 0.0458333 | 0.114583 | 32 mmø-25 mmø | 0.104987 | 0.082021
706001 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8055 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
706131 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8069 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
706132 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8070 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
706270 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8083 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
706271 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8084 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
706305 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8088 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
706509 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8100 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
706510 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8101 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
706541 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -273.012 | Level: Level 1 | Level : Level 1 | 8105 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
706567 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 300 | Level: Level 1 | Level : Level 1 | 8108 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
706603 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 300 | Level: Level 1 | Level : Level 1 | 8110 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
706618 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8114 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
706662 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8115 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
706663 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8116 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
706925 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8144 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
707068 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8162 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
707069 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8163 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
707125 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8166 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
707150 | TOF Footing | 0.0260417 | 10 | yes | no | 0.0729167 | no | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8169 | 0.0729167 | 0.0246063 | 0.0182292 | 0.0246063 | 0.0246063 | 0.0328084 | 0.0291667 | 0.0208333 | 0.0520833 | 20 mmø-15 mmø | 0.0492126 | 0.0656168
707185 | TOF Footing | 0.0364583 | 10 | yes | no | 0.114583 | no | 0.0572917 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8184 | 0.114583 | 0.0328084 | 0.0286458 | 0.0328084 | 0.0328084 | 0.0524934 | 0.0458333 | 0.0291667 | 0.0729167 | 32 mmø-20 mmø | 0.0656168 | 0.104987
707224 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8195 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
707265 | TOF Footing | 0.0260417 | 10 | yes | no | 0.114583 | no | 0.0572917 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8198 | 0.114583 | 0.0246063 | 0.0286458 | 0.0246063 | 0.0246063 | 0.0524934 | 0.0458333 | 0.0208333 | 0.0520833 | 32 mmø-15 mmø | 0.0492126 | 0.104987
707298 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.046875 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8208 | 0.09375 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0410105 | 0.0375 | 0.0458333 | 0.114583 | 32 mmø-25 mmø | 0.104987 | 0.082021
707324 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8215 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
707436 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 8239 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
707526 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8255 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
707569 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8256 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
707587 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8258 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
707727 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -250 | Level: Level 1 | Level : Level 1 | 8263 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
707747 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8267 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
707833 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8281 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
707834 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8282 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
707959 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8305 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
707972 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8310 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
708029 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8320 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
708082 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8330 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
708083 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8331 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
708105 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8335 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
708235 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 688.244 | Level: Level 1 | Level : Level 1 | 8353 | 0.09375 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0410105 | 0.0375 | 0.0541667 | 0.135417 | 40 mmø-25 mmø | 0.131234 | 0.082021
708258 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.046875 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 688.244 | Level: Level 1 | Level : Level 1 | 8354 | 0.09375 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0410105 | 0.0375 | 0.0541667 | 0.135417 | 40 mmø-25 mmø | 0.131234 | 0.082021
708277 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 688.244 | Level: Level 1 | Level : Level 1 | 8363 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
708299 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8364 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
708300 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8365 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
708358 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -250 | Level: Level 1 | Level : Level 1 | 8369 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
708410 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8375 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
708516 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8389 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
708517 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8390 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
708539 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8394 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
708621 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8410 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
708622 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8411 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
708801 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8438 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
708872 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8439 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
708873 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8440 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
708895 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8444 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
708975 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8453 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
708976 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8454 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
709022 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8458 | 0.0729167 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0328084 | 0.0291667 | 0.0458333 | 0.114583 | 32 mmø-20 mmø | 0.104987 | 0.0656168
709179 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8484 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
709180 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8485 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
709347 | TOF Footing | 0.0260417 | 10 | yes | no | 0.135417 | no | 0.0677083 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -285.713 | Level: Level 1 | Level : Level 1 | 8496 | 0.135417 | 0.0246063 | 0.0338542 | 0.0246063 | 0.0246063 | 0.0656168 | 0.0541667 | 0.0208333 | 0.0520833 | 40 mmø-15 mmø | 0.0492126 | 0.131234
709394 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8499 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
709395 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8500 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
709595 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8518 | 0.0729167 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0328084 | 0.0291667 | 0.0458333 | 0.114583 | 32 mmø-20 mmø | 0.104987 | 0.0656168
709696 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8533 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
709697 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8534 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
709717 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -250 | Level: Level 1 | Level : Level 1 | 8536 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
709718 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -250 | Level: Level 1 | Level : Level 1 | 8537 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
709820 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -250 | Level: Level 1 | Level : Level 1 | 8560 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
709821 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -250 | Level: Level 1 | Level : Level 1 | 8561 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
709847 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8565 | 0.0729167 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0328084 | 0.0291667 | 0.0458333 | 0.114583 | 32 mmø-20 mmø | 0.104987 | 0.0656168
710097 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8579 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
710205 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8587 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
710206 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8588 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
710244 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8592 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
710351 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8605 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
710352 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8606 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
710387 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8610 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
710486 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8626 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
710487 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8627 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
710523 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8631 | 0.0729167 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0328084 | 0.0291667 | 0.0458333 | 0.114583 | 32 mmø-20 mmø | 0.104987 | 0.0656168
710641 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 894.556 | Level: Level 1 | Level : Level 1 | 8641 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
710738 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8652 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
710739 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8653 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
710827 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8657 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
710908 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8663 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
710909 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8664 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
710966 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8666 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
710967 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8667 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
710994 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8677 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
711026 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8689 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
711108 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8702 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
711109 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8703 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
711135 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8707 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
711184 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8721 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
711263 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8733 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
711444 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8753 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
711445 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8754 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
711465 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8755 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
711466 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8756 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
711498 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8757 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
711499 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8758 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
711575 | TOF Footing | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8762 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
711670 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8771 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
711671 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -300 | Level: Level 1 | Level : Level 1 | 8772 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
711693 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 8773 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
711694 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 8774 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
711854 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.046875 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1430 | Level: Level 2 | Level : Level 2 | 8800 | 0.09375 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0410105 | 0.0375 | 0.0541667 | 0.135417 | 40 mmø-25 mmø | 0.131234 | 0.082021
712274 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 8846 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
712614 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 8856 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
712686 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 8866 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
712687 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 8867 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
712762 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 8874 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
712870 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 8879 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
712871 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 8880 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
712900 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 8881 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
712901 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 8882 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
712964 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1430 | Level: Level 2 | Level : Level 2 | 8888 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
713001 | Level 1 | 0.0260417 | 10 | yes | no | 0.114583 | no | 0.0572917 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1430 | Level: Level 2 | Level : Level 2 | 8894 | 0.114583 | 0.0246063 | 0.0286458 | 0.0246063 | 0.0246063 | 0.0524934 | 0.0458333 | 0.0208333 | 0.0520833 | 32 mmø-15 mmø | 0.0492126 | 0.104987
713043 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1430 | Level: Level 2 | Level : Level 2 | 8902 | 0.0520833 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0246063 | 0.0208333 | 0.0541667 | 0.135417 | 40 mmø-15 mmø | 0.131234 | 0.0492126
713112 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 8906 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
713113 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 8907 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
713159 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1430 | Level: Level 2 | Level : Level 2 | 8908 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
713160 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1430 | Level: Level 2 | Level : Level 2 | 8909 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
713192 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1430 | Level: Level 2 | Level : Level 2 | 8913 | 0.0520833 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0246063 | 0.0208333 | 0.0541667 | 0.135417 | 40 mmø-15 mmø | 0.131234 | 0.0492126
713302 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1430 | Level: Level 2 | Level : Level 2 | 8926 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
713303 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1430 | Level: Level 2 | Level : Level 2 | 8927 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
713328 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 8931 | 0.0520833 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0246063 | 0.0208333 | 0.0541667 | 0.135417 | 40 mmø-15 mmø | 0.131234 | 0.0492126
713417 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 8943 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
713418 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 8944 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
713634 | Level 1 | 0.0260417 | 10 | yes | no | 0.0729167 | no | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1350 | Level: Level 2 | Level : Level 2 | 8963 | 0.0729167 | 0.0246063 | 0.0182292 | 0.0246063 | 0.0246063 | 0.0328084 | 0.0291667 | 0.0208333 | 0.0520833 | 20 mmø-15 mmø | 0.0492126 | 0.0656168
713919 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9009 | 0.0729167 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0328084 | 0.0291667 | 0.0541667 | 0.135417 | 40 mmø-20 mmø | 0.131234 | 0.0656168
714002 | Level 1 | 0.0572917 | 10 | yes | no | 0.135417 | no | 0.0677083 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 3170 | Level: Level 1 | Level : Level 1 | 9025 | 0.135417 | 0.0524934 | 0.0338542 | 0.0524934 | 0.0524934 | 0.0656168 | 0.0541667 | 0.0458333 | 0.114583 | 40 mmø-32 mmø | 0.104987 | 0.131234
714033 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9028 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
714091 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1350 | Level: Level 2 | Level : Level 2 | 9030 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
714211 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 9032 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
714212 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 9033 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
714300 | Level 1 | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0885417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9037 | 0.177083 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.082021 | 0.0708333 | 0.0875 | 0.21875 | 65 mmø-50 mmø | 0.213255 | 0.164042
714453 | Level 1 | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0677083 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9051 | 0.135417 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0656168 | 0.0541667 | 0.0875 | 0.21875 | 65 mmø-40 mmø | 0.213255 | 0.131234
714479 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9055 | 0.0729167 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0328084 | 0.0291667 | 0.0541667 | 0.135417 | 40 mmø-20 mmø | 0.131234 | 0.0656168
714580 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9066 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
714850 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9090 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
715039 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9104 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
715040 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9105 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
715257 | Level 1 | 0.0677083 | 10 | yes | no | 0.21875 | no | 0.109375 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9115 | 0.21875 | 0.0656168 | 0.0546875 | 0.0656168 | 0.0656168 | 0.106627 | 0.0875 | 0.0541667 | 0.135417 | 65 mmø-40 mmø | 0.131234 | 0.213255
715270 | Level 1 | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9119 | 0.0520833 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0246063 | 0.0208333 | 0.0875 | 0.21875 | 65 mmø-15 mmø | 0.213255 | 0.0492126
715392 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9135 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
715393 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9136 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
715528 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9143 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
715804 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9180 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
715805 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9181 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0410105 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-25 mmø | 0.164042 | 0.082021
715827 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9185 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
715981 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9195 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
715982 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9196 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
716004 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9200 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
716019 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9206 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
716281 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9225 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
716447 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9241 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
