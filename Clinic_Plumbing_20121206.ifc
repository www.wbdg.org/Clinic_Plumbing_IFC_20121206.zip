Properties of the parts of a building model (IFC2X3), part 1 of 29

# File
Description: ViewDefinition [CoordinationView]
File name: Clinic_MEP_Plumbing_120612.ifc
Time: 2012-12-18T09:15:29
Written by: Autodesk Revit 2013
Made in: 20121003_2115(x64)

# IfcProject, 100001
LongName: MEDICAL CLINC; Phase: NEW

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm

# IfcBuilding, Medical Clinic
LongName: Medical Clinic
Pset_BuildingCommon - BuildingID: 001; OccupancyType: COMMERCIAL; YearOfConstruction: 2001; NumberOfStoreys: 3
Text - NumberOfStoreys: 2; Water: 000; OccupancyType: COMMERCIAL; IsPermanentID: 11111; NetPlannedArea: 50,000; GrossPlannedArea: 60,000; Fuel: 000; SprinklerProtection: YES; IsLandmarked: NO; SprinklerProtectionAutomatic: YES; YearOfConstruction: 2001; ConstructionMethod: NEW; YearOfLastRefurbishment: 2008; Steam: 000; FireProtectionClass: TYPE IIB; BuildingID: 001; Electricity: 000; Heat: 000
Other - Project Number: 100001; Project Status: NEW; Client Name: XYZ; Project Address: Enter address here; Project Name: MEDICAL CLINC; Project Issue Date: 2000; Category Code: 11-21 15 00; Category Description: Outpatient Care Facility
Identity Data - Author: KFA; Organization Description: XYZ TECHNOLOGIES; Building Name: Medical Clinic; Organization Name: XYZ

# IfcBuildingStorey (3)
In: Medical Clinic
Constraints - Elevation Base: 0
Graphics - Line Weight: 1; Symbol at End 2 Default: yes; Symbol at End 1 Default: no; Line Pattern: Centre; Symbol: M_Level Head - Circle: M_Level Head - Circle; Color: 0
Other - Category Code: Floor
Identity Data - Building Story: yes; Structural: no
Name | LongName = Name | Elevation (mm) | Computation Height (mm) | Constraints, Elevation (mm)
TOF Footing | TOF Footing | -1000 | 0 | -1000
Level 1 | Level 1 | -2.82087e-10 | 1200 | 0
Level 2 | Level 2 | 4570 | 1200 | 4570

# IfcDistributionPort: IfcDistributionPort (13058)
Name | FlowDirection
11150 x  | SOURCEANDSINK
954 x  | SINK
954 x  | SOURCE

# IfcFlowController: 100 mm, M_Ball Valve - 50-150 mm:100 mm:100 mm:1060496
In: TOF Footing
Type - ElementType: 100 mm; Classification:  (UniFormat)
Text - WorkingPressure: 1206582; FlowCoefficient: 90
Dimensions - Adapter Radius: 80 mm; Seal Length: 57.25 mm; Nominal Radius: 0.164042; Nut Radius: 15 mm; Body Diameter: 110 mm; Stem Diameter: 20 mm; Stem Height: 55 mm; Nominal Diameter: 0.328084; Handle Height: 502 mm; Handle Length: 178 mm; Stem Radius: 10 mm; Body Height: 143 mm; Nut Diameter: 30 mm; Handle Width: 51 mm; Nut Height: 33 mm; Adapter Length: 22.9 mm; Body Radius: 55 mm; Adapter Diameter: 160 mm; Body Length: 229 mm; Size: 100 mmø-100 mmø
Mechanical - K Coefficient: 0.3; System Type: Piping System: Domestic Cold Water 1; System Name: Domestic Cold Water 1; System Classification: Domestic Cold Water; Loss Method: 5
Other - Material: N/A; Shape: N/A; NominalLength: 0; MeasuredFlowRate: 0.25; Length 1: 183.2 mm; Radius: 117.5 mm; ValveOperation: LEVER; ValveMechanism: OTHER; Constituents: N/A; ModelReference: N/A; AssetAccountingType: FIXED; Half Nut Height: 16.5 mm; ModelLabel: N/A; SustainabilityPerformance: N/A; Grade: N/A; Size: 100; WarrantyGuarantorLabor: N/A; MeasuredPressureDrop: 34473; TestPressure: 2413165; ProductionYear: N/A; CloseRating: 40000; ReplacementCost: N/A; Features: N/A; WarrantyGuarantorParts: N/A; NominalWidth: 0; ExpectedLife: N/A; WarrantyDescription: N/A; NominalHeight: 0; WarrantyDurationParts: N/A; Length 2: 57.25 mm; AccessibilityPerformance: N/A; PercentageOpen: 7; WarrantyDurationLabor: N/A; BodyMaterial: Brass; CodePerformance: N/A; Reference: Type G - 1; ValvePattern: STRAIGHT; AssetIdentifier: N/A; UpstreamPressure: 0; TagNumber: N/A; BarCode: N/A; WarrantyStartDate: N/A; DownstreamPressure: 0; SerialNumber: N/A; InstallationDate: N/A
Identity Data - Manufacturer: N/A; OmniClass Title: Adjusting/Controlling Valves for Liquid Services; OmniClass Number: 23.65.55.14.17; Mark: 179
Phasing - Phase Created: New Construction
Constraints - Level: Level: Level 1; Offset: -512.678 mm; Host: Level : Level 1
Insulation - Overall Size: 100 mmø-100 mmø
Graphics - Use Annotation Scale: yes

# IfcFlowController: 150 mm, M_Ball Valve - 50-150 mm:150 mm:150 mm:1060602
In: Level 1
Type - ElementType: 150 mm; Classification:  (UniFormat)
Identity Data - OmniClass Number: 23.65.55.14.17; OmniClass Title: Adjusting/Controlling Valves for Liquid Services; Manufacturer: N/A; Mark: 180
Text - FlowCoefficient: 90; WorkingPressure: 1206582
Other - Size: 150; CodePerformance: N/A; PercentageOpen: 7; Half Nut Height: 24.75 mm; Reference: Type H - 1; WarrantyDescription: N/A; NominalHeight: 0; Radius: 142.5 mm; Constituents: N/A; BodyMaterial: Brass; ValveMechanism: OTHER; WarrantyGuarantorLabor: N/A; MeasuredPressureDrop: 34473; ProductionYear: N/A; Features: N/A; ExpectedLife: N/A; Grade: N/A; ReplacementCost: N/A; Length 1: 223.2 mm; Shape: N/A; SustainabilityPerformance: N/A; WarrantyDurationParts: N/A; ValveOperation: LEVER; Material: N/A; MeasuredFlowRate: 0.25; ModelReference: N/A; ModelLabel: N/A; ValvePattern: STRAIGHT; NominalWidth: 0; WarrantyDurationLabor: N/A; CloseRating: 40000; WarrantyGuarantorParts: N/A; TestPressure: 2413165; AssetAccountingType: FIXED; AccessibilityPerformance: N/A; Length 2: 69.75 mm; NominalLength: 0; DownstreamPressure: 0; InstallationDate: N/A; AssetIdentifier: N/A; BarCode: N/A; TagNumber: N/A; SerialNumber: N/A; UpstreamPressure: 0; WarrantyStartDate: N/A
Mechanical - K Coefficient: 0.28; System Classification: Undefined; Loss Method: 5
Dimensions - Body Height: 214.5 mm; Nut Diameter: 45 mm; Nominal Diameter: 0.492126; Body Diameter: 165 mm; Handle Length: 259 mm; Stem Height: 82.5 mm; Adapter Radius: 120 mm; Body Length: 279 mm; Handle Height: 660 mm; Adapter Length: 27.9 mm; Nut Radius: 22.5 mm; Stem Diameter: 30 mm; Handle Width: 51 mm; Nominal Radius: 0.246063; Adapter Diameter: 240 mm; Nut Height: 49.5 mm; Stem Radius: 15 mm; Body Radius: 82.5 mm; Seal Length: 69.75 mm; Size: 150 mmø-150 mmø
Constraints - Offset: 2985 mm; Host: Level : Level 1; Level: Level: Level 1
Phasing - Phase Created: New Construction
Graphics - Use Annotation Scale: yes
Insulation - Overall Size: 150 mmø-150 mmø

# IfcFlowController: 20 mm, M_Backflow Preventer - 15-50 mm:20 mm:20 mm:1054811
In: Level 1
Type - ElementType: 20 mm; Classification:  (UniFormat)
Text - FlowCoefficient: 90; WorkingPressure: 1206582
Identity Data - OmniClass Number: 23.65.55.14.21; Manufacturer: N/A; OmniClass Title: Non-Return Valves for Liquid Services; Mark: 178
Dimensions - Body Length: 195 mm; Nominal Radius: 0.0328084; C1 Offset 2: 52 mm; Valve Length: 308 mm; Nominal Diameter: 0.0656168; C1 Offset 1: 89 mm; Outside Diameter: 24 mm; Width 1: 27 mm; Open Height: 127 mm; Size: 20 mmø-20 mmø
Other - NominalWidth: 0; ReplacementCost: N/A; TestPressure: 2413165; Reference: Type C - 1; Length 1: 32.5 mm; WarrantyDescription: N/A; ModelLabel: N/A; NominalLength: 0; ExpectedLife: N/A; ProductionYear: N/A; CloseRating: 45000; Radius 10: 20.25 mm; Radius 4: 9 mm; Features: N/A; AccessibilityPerformance: N/A; ValveOperation: LEVER; Constituents: N/A; AssetAccountingType: FIXED; Radius 1: 12.7 mm; Grade: N/A; Radius 3: 10.8 mm; BodyMaterial: Brass; Length 6: 12.0604 mm; MeasuredFlowRate: 0.25; Outside Radius: 12 mm; Height 3: 16.2 mm; Length 3: 8.125 mm; Angle 1: 45 deg; Length 5: 48.2418 mm; Radius 7: 7.2 mm; Thickness 1: 3 mm; Height 1: 36 mm; Material: N/A; ModelReference: N/A; CodePerformance: N/A; Length 9: 10.5529 mm; Shape: N/A; Radius 2: 19.1 mm; Length 7: 18.0907 mm; Height 2: 48 mm; MeasuredPressureDrop: 34473; ValvePattern: STRAIGHT; Width 2: 5.4 mm; WarrantyDurationParts: N/A; Length: 120.604 mm; Length 2: 19.1 mm; WarrantyGuarantorParts: N/A; PercentageOpen: 12; NominalHeight: 0; ValveMechanism: OTHER; Radius 5: 25.65 mm; Length 4: 6.03022 mm; Angle 2: 45 deg; Radius 8: 3 mm; Length 8: 1.50756 mm; WarrantyGuarantorLabor: N/A; Height 5: 12 mm; SustainabilityPerformance: N/A; Height 4: 1.8 mm; WarrantyDurationLabor: N/A; Radius 6: 27 mm; Radius 9: 4.8 mm; Height 6: 6 mm; Size: 20; WarrantyStartDate: N/A; BarCode: N/A; TagNumber: N/A; DownstreamPressure: 34473; AssetIdentifier: N/A; UpstreamPressure: 68947; InstallationDate: N/A; SerialNumber: N/A
Mechanical - Loss Method: 5; Pressure Drop: 10717.7; System Name: Domestic Hot Water 1,Domestic Hot Water 2; System Classification: Domestic Cold Water,Domestic Hot Water
Constraints - Host: Level : Level 2; Level: Level: Level 2; Offset: -1350 mm
Insulation - Overall Size: 20 mmø-20 mmø
Phasing - Phase Created: New Construction
Graphics - Use Annotation Scale: yes

# IfcFlowController: 50 mm (167)
Type - ElementType: 50 mm; Classification:  (UniFormat)
Text - FlowCoefficient: 90; WorkingPressure: 1206852
Mechanical - K Coefficient: 0.35; System Classification: Domestic Cold Water; Loss Method: 5
Dimensions - Nut Height: 16.5 mm; Adapter Radius: 40 mm; Body Diameter: 55 mm; Adapter Diameter: 80 mm; Seal Length: 44.5 mm; Body Length: 178 mm; Stem Height: 27.5 mm; Nominal Diameter: 0.164042; Handle Length: 127 mm; Body Radius: 27.5 mm; Stem Radius: 5 mm; Body Height: 71.5 mm; Stem Diameter: 10 mm; Nominal Radius: 0.082021; Handle Height: 229 mm; Handle Width: 25 mm; Nut Diameter: 15 mm; Nut Radius: 7.5 mm; Adapter Length: 17.8 mm; Size: 50 mmø-50 mmø
Other - ValvePattern: STRAIGHT; NominalHeight: 0; ProductionYear: N/A; CodePerformance: N/A; Constituents: N/A; Grade: N/A; ExpectedLife: N/A; Half Nut Height: 8.25 mm; ReplacementCost: N/A; Length 1: 142.4 mm; TestPressure: 2413165; WarrantyDescription: N/A; PercentageOpen: 7; SustainabilityPerformance: N/A; NominalLength: 0; Reference: Type D - 1; ValveOperation: LEVER; NominalWidth: 0; Length 2: 44.5 mm; Size: 50; CloseRating: 50000; Features: N/A; Shape: N/A; ValveMechanism: OTHER; Material: N/A; AssetAccountingType: FIXED; Radius: 92 mm; BodyMaterial: Brass; ModelReference: N/A; WarrantyGuarantorParts: N/A; AccessibilityPerformance: N/A; WarrantyGuarantorLabor: N/A; WarrantyDurationLabor: N/A; ModelLabel: N/A; MeasuredPressureDrop: 34473; WarrantyDurationParts: N/A; MeasuredFlowRate: 0.25; WarrantyStartDate: N/A; UpstreamPressure: 0; SerialNumber: N/A; AssetIdentifier: N/A; BarCode: N/A; DownstreamPressure: 0; InstallationDate: N/A; TagNumber: N/A
Identity Data - Manufacturer: N/A; OmniClass Number: 23.65.55.14.17; OmniClass Title: Adjusting/Controlling Valves for Liquid Services
Graphics - Use Annotation Scale: yes
Insulation - Overall Size: 50 mmø-50 mmø
Phasing - Phase Created: New Construction
Name (M_Ball Valve - 50-150 mm:50 mm:50 mm:...) | In | System Type | System Name | Host | Level | Offset (mm) | Mark
677946 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 2
678388 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 3
678544 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 4
678780 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 5
678902 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 6
678985 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 7
679158 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 9
679734 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 10
679912 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 11
680142 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 12
680360 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 13
680512 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 14
680866 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 16
680955 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 17
681320 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 18
681608 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 19
681789 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 20
681993 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 21
682634 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 22
682810 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 23
683673 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 24
683963 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 25
684108 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 26
684566 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 27
684733 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 28
684928 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 29
685092 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 30
685393 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 31
685574 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 32
685898 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 33
686477 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 34
686685 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 35
686819 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 36
687064 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 37
687167 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 38
687717 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 39
687890 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 40
688106 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 41
688237 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 42
688479 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 43
688819 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 45
688995 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 46
689214 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 47
689335 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 48
689452 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 49
689734 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 51
689789 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 52
690000 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 53
690120 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 54
690249 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 55
690351 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 56
690481 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 57
691415 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 58
692504 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 59
692987 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 60
693699 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 61
694243 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 62
694543 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 63
694756 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 64
694960 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 65
695191 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 66
695214 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 67
695343 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 68
695522 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 69
696516 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 70
696720 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 71
696843 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 72
696961 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 73
697150 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 74
697331 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 75
698108 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 76
699081 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 77
699794 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 78
700016 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 79
700230 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 80
700570 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 81
700687 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 82
701192 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 83
701325 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 84
701542 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 85
701632 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 86
701674 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -350 | 87
701697 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 88
701822 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 89
702027 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 90
702042 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 91
702315 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 92
702761 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 93
703318 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 94
703645 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 95
703675 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -350 | 96
703964 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 97
704116 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 98
704298 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 99
704348 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 100
704462 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 101
704549 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 102
704564 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 103
705334 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -250 | 104
705349 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -250 | 105
705714 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -250 | 106
705930 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -250 | 107
706121 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 108
706260 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 109
706502 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 110
706564 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | 300 | 111
706649 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 112
706911 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 113
707065 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 114
707522 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 115
707723 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -250 | 116
707830 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 117
708079 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 118
708296 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 119
708509 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 120
708618 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 121
708869 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 122
708968 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 123
709176 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 124
709391 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 125
709693 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 126
709817 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -250 | 127
710192 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 128
710344 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 129
710478 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 130
710727 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 131
710893 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 132
711105 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 133
711436 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 134
711462 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 135
711495 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 136
711661 | TOF Footing | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 1 | Level: Level 1 | -300 | 137
711687 | TOF Footing | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 1 | Level: Level 1 | -512.678 | 138
712254 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1400 | 139
712867 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 140
712897 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1400 | 141
713103 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 142
713141 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1430 | 143
713299 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1430 | 144
713414 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 145
714024 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1400 | 146
714079 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1350 | 147
714202 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 148
715036 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1400 | 149
715385 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1400 | 150
715801 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1400 | 151
715978 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1400 | 152
716433 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1400 | 153
716496 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1350 | 154
716696 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1400 | 155
716909 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1400 | 156
717082 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1400 | 157
717219 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1400 | 158
717359 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1400 | 159
717486 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1400 | 160
717694 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1400 | 161
717822 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1400 | 162
718479 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1400 | 163
718612 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1400 | 164
718781 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1400 | 165
718977 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1400 | 166
719068 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1400 | 167
719098 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1350 | 168
719283 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1450 | 169
719506 | Level 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | Level : Level 2 | Level: Level 2 | -1450 | 170
719540 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 171
719742 | Level 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | Level : Level 2 | Level: Level 2 | -1500 | 172

# IfcFlowController: 65 mm (2)
In: Level 1
Type - ElementType: 65 mm; Classification:  (UniFormat)
Mechanical - K Coefficient: 0.32; System Classification: Domestic Cold Water; Loss Method: 5
Identity Data - OmniClass Number: 23.65.55.14.17; OmniClass Title: Adjusting/Controlling Valves for Liquid Services; Manufacturer: N/A
Text - FlowCoefficient: 90; WorkingPressure: 1206582
Other - ModelReference: N/A; ValvePattern: STRAIGHT; ExpectedLife: N/A; MeasuredPressureDrop: 34473; TestPressure: 2413165; NominalHeight: 0; CodePerformance: N/A; WarrantyGuarantorLabor: N/A; ModelLabel: N/A; AccessibilityPerformance: N/A; WarrantyDescription: N/A; WarrantyDurationParts: N/A; NominalWidth: 0; Length 1: 152.8 mm; ProductionYear: N/A; Shape: N/A; Features: N/A; MeasuredFlowRate: 0.25; Reference: Type E - 1; Constituents: N/A; CloseRating: 45000; Radius: 98.5 mm; WarrantyGuarantorParts: N/A; WarrantyDurationLabor: N/A; Length 2: 47.75 mm; PercentageOpen: 7; Grade: N/A; Size: 65; ValveMechanism: OTHER; Half Nut Height: 10.725 mm; Material: N/A; BodyMaterial: Brass; ValveOperation: LEVER; AssetAccountingType: FIXED; SustainabilityPerformance: N/A; NominalLength: 0; ReplacementCost: N/A; TagNumber: N/A; InstallationDate: N/A; UpstreamPressure: 0; DownstreamPressure: 0; SerialNumber: N/A; BarCode: N/A; AssetIdentifier: N/A; WarrantyStartDate: N/A
Dimensions - Body Length: 191 mm; Stem Height: 35.75 mm; Body Height: 92.95 mm; Nut Height: 21.45 mm; Seal Length: 47.75 mm; Nut Radius: 9.75 mm; Nominal Diameter: 0.213255; Nut Diameter: 19.5 mm; Handle Length: 140 mm; Stem Radius: 6.5 mm; Adapter Length: 19.1 mm; Stem Diameter: 13 mm; Body Radius: 35.75 mm; Handle Width: 38.1 mm; Adapter Diameter: 104 mm; Nominal Radius: 0.106627; Adapter Radius: 52 mm; Body Diameter: 71.5 mm; Handle Height: 406 mm; Size: 65 mmø-65 mmø
Constraints - Host: Level : Level 2; Level: Level: Level 2
Phasing - Phase Created: New Construction
Insulation - Overall Size: 65 mmø-65 mmø
Graphics - Use Annotation Scale: yes
Name (M_Ball Valve - 50-150 mm:65 mm:65 mm:...) | System Type | System Name | Offset (mm) | Mark
1054726 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | -1500 | 175
1054735 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | -1400 | 176

# IfcFlowController: 80 mm, M_Ball Valve - 50-150 mm:80 mm:80 mm:688571
In: TOF Footing
Type - ElementType: 80 mm; Classification:  (UniFormat)
Mechanical - K Coefficient: 0.31; System Name: Domestic Cold Water 1; System Type: Piping System: Domestic Cold Water 1; Loss Method: 5; System Classification: Domestic Cold Water
Dimensions - Nut Height: 26.4 mm; Nominal Diameter: 0.262467; Seal Length: 50.75 mm; Stem Height: 44 mm; Body Radius: 44 mm; Adapter Radius: 64 mm; Handle Height: 406 mm; Stem Radius: 8 mm; Nominal Radius: 0.131234; Handle Length: 159 mm; Nut Diameter: 24 mm; Stem Diameter: 16 mm; Body Length: 203 mm; Body Height: 114.4 mm; Nut Radius: 12 mm; Handle Width: 38 mm; Adapter Length: 20.3 mm; Adapter Diameter: 128 mm; Body Diameter: 88 mm; Size: 80 mmø-80 mmø
Text - WorkingPressure: 1206582; FlowCoefficient: 90
Identity Data - OmniClass Number: 23.65.55.14.17; OmniClass Title: Adjusting/Controlling Valves for Liquid Services; Manufacturer: N/A; Mark: 44
Other - PercentageOpen: 7; MeasuredFlowRate: 0.25; WarrantyDurationParts: N/A; ModelReference: N/A; TestPressure: 2413165; NominalWidth: 0; ReplacementCost: N/A; Size: 80; BodyMaterial: Brass; CloseRating: 40000; ProductionYear: N/A; Material: N/A; ModelLabel: N/A; WarrantyDurationLabor: N/A; Shape: N/A; WarrantyGuarantorParts: N/A; WarrantyDescription: N/A; WarrantyGuarantorLabor: N/A; AssetAccountingType: FIXED; ExpectedLife: N/A; SustainabilityPerformance: N/A; Length 1: 162.4 mm; ValvePattern: STRAIGHT; Half Nut Height: 13.2 mm; ValveOperation: LEVER; Constituents: N/A; MeasuredPressureDrop: 34473; ValveMechanism: OTHER; Grade: N/A; Length 2: 50.75 mm; Radius: 104.5 mm; Reference: Type F - 1; Features: N/A; CodePerformance: N/A; NominalHeight: 0; NominalLength: 0; AccessibilityPerformance: N/A; TagNumber: N/A; SerialNumber: N/A; InstallationDate: N/A; WarrantyStartDate: N/A; UpstreamPressure: 0; BarCode: N/A; AssetIdentifier: N/A; DownstreamPressure: 0
Graphics - Use Annotation Scale: yes
Insulation - Overall Size: 80 mmø-80 mmø
Constraints - Level: Level: Level 1; Offset: -512.678 mm; Host: Level : Level 1
Phasing - Phase Created: New Construction

# IfcFlowController: Kitchen Sink Faucet (36)
Type - ElementType: Kitchen Sink Faucet; Classification:  (UniFormat)
Text - OutletConnectionSize: 25; Finish: Chrome; WorkingPressure: 172000; FlowCoefficient: 94
Dimensions - Cold Water Connection Radius: 11.1125 mm; Hot Water Connection Radius: 11.1125 mm
Materials and Finishes - Escutcheon: Polished Chrome; Locknut: Plastic; Wristblade Handle Assy. (Pair): Polished Chrome; Spout Base Escutcheon: Polished Chrome; Spout Assembly: Polished Chrome; Index Button (Red): Molded Plastic-Red; Softflo Outlet: Polished Chrome; Valve Body Not Sold Separately: Brass; Hanger: Galvanized Steel; Coupling Nut: Brass; Index Button (Blue): Molded Plastic-Blue
Identity Data - Description: Concealed Kitchen Sink Faucet; Specification: Chicago Faucets No. 786-E3ABCP, polished chrome plated solid brass body and spout. ECAST® construction with less than 0.25% lead content by weighted average. 5-1/4" C-C rigid/swing field convertible gooseneck spout. 2.2 GPM pressure compensating aerator outlet. 4" wristblade handles with eight-point tapered broach and secured, color-coded index buttons. Quaturn™ quarter-turn renewable compression cartridge designed to close with water pressure, with square tapered broach feature to help facilitate handle removal. 8" rigid valve body centers with 1/2" NPSM inlets and coupling nuts for 3/8" or 1/2" flexible risers. Mounting hardware included. This product meets ADA ANSI/ICC A117.1 requirements and is tested and certified to industry standards: ASME A112.18.1M, CSA B125.1, Certified to NSF/ANSI 61, Section 9 by CSA, California Health and Safety Code 116875 (AB1953-2006), and Vermont Bill S.152.; Manufacturer: N/A; URL: www.chicagofaucets.com; Model: 786-E3ABCP
Other - ReplacementCost: N/A; AssetAccountingType: FIXED; ModelLabel: N/A; WarrantyGuarantorLabor: N/A; Material: N/A; Aerator: 2.2 GPM (8.3 L/min) Pressure; FaucetType: SINGLEOUTLETCOMBINATION; TestPressure: 1724000; NominalWidth: 0; HasGrabHandles: TRUE; FaucetTopDescription: Cartridge; MixerControl: MANUAL; FaucetOperation: LEVERHANDLE; NominalDepth: 1; Shape: N/A; AccessibilityPerformance: N/A; Constituents: N/A; WarrantyDurationParts: N/A; Rated Operating Temperature: 40-140ºF; WarrantyDescription: N/A; Finish: Chrome; BodyMaterial: Chrome; ExpectedLife: N/A; WarrantyGuarantorParts: N/A; ProductionYear: N/A; Rated Operating Pressure: 20-125 PSI; ModelReference: N/A; Code Compliance: ASME A112.18.1M,CSA B125.1,Certified to NSF/ANSI 61, Section 9 by CSA,California Health and Safety Code 116875 (AB1953-2006),Vermont Bill S.152,ADA ANSI/ICC A117.1; HasTray: TRUE; Color: White; ShowerHeadDescription: Fixed; MeasuredFlowRate: 0.13; Size: 25; ValveOperation: OTHER; Reference: Type A - 1; WarrantyDurationLabor: N/A; CodePerformance: N/A; DrainSize: 0; MountingOffset: 0; Grade: N/A; NominalLength: 0; CloseRating: 690000; ValvePattern: ALIGNED_2_PORT; FaucetFunction: MIXED; SustainabilityPerformance: N/A; Features: N/A; PercentageOpen: 5; NominalHeight: 0; SpilloverLevel: 0; ValveMechanism: BALL; MeasuredPressureDrop: 34473; InstallationDate: N/A; TagNumber: N/A; SerialNumber: N/A; AssetIdentifier: N/A; BarCode: N/A; WarrantyStartDate: N/A
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Phasing - Phase Created: New Construction
Name (Kitchen Sink Faucet:Kitchen Sink Faucet:Kitchen Sink Faucet:...) | In | System Name | Mark | Level | Offset (mm) | Host
1179634 | Level 2 | Domestic Hot Water 3,Unit B Domestic Cold Water 1 | 176 | Level: Level 1 | 5482.7 | Level : Level 1
1182503 | Level 2 | Domestic Hot Water 4,Unit B Domestic Cold Water 2 | 177 | Level: Level 1 | 5482.7 | Level : Level 1
1182546 | Level 2 | Domestic Hot Water 5,Unit B Domestic Cold Water 3 | 178 | Level: Level 1 | 5482.7 | Level : Level 1
1182789 | Level 2 | Domestic Hot Water 6,Unit B Domestic Cold Water 4 | 179 | Level: Level 1 | 5482.7 | Level : Level 1
1182893 | Level 2 | Domestic Hot Water 7,Unit B Domestic Cold Water 5 | 180 | Level: Level 1 | 5482.7 | Level : Level 1
1183009 | Level 2 | Domestic Hot Water 8,Unit B Domestic Cold Water 6 | 181 | Level: Level 1 | 5482.7 | Level : Level 1
1183095 | Level 2 | Domestic Hot Water 9,Unit B Domestic Cold Water 7 | 182 | Level: Level 1 | 5482.7 | Level : Level 1
1183192 | Level 2 | Domestic Hot Water 10,Unit B Domestic Cold Water 8 | 183 | Level: Level 1 | 5482.7 | Level : Level 1
1183402 | Level 2 | Domestic Hot Water 11,Unit B Domestic Cold Water 9 | 184 | Level: Level 1 | 5482.7 | Level : Level 1
1183499 | Level 2 | Domestic Hot Water 12,Unit B Domestic Cold Water 10 | 185 | Level: Level 1 | 5482.7 | Level : Level 1
1183593 | Level 2 | Domestic Hot Water 13,Unit B Domestic Cold Water 11 | 186 | Level: Level 1 | 5482.7 | Level : Level 1
1183606 | Level 2 | Domestic Hot Water 14,Unit B Domestic Cold Water 12 | 187 | Level: Level 1 | 5482.7 | Level : Level 1
1183748 | Level 2 | Domestic Hot Water 15,Unit B Domestic Cold Water 13 | 188 | Level: Level 1 | 5482.7 | Level : Level 1
1183849 | Level 2 | Domestic Hot Water 16,Unit B Domestic Cold Water 14 | 189 | Level: Level 1 | 5482.7 | Level : Level 1
1183932 | Level 2 | Domestic Hot Water 17,Unit B Domestic Cold Water 15 | 190 | Level: Level 1 | 5482.7 | Level : Level 1
1184159 | Level 2 | Domestic Hot Water 18,Unit B Domestic Cold Water 16 | 191 | Level: Level 1 | 5482.7 | Level : Level 1
1184251 | Level 2 | Domestic Hot Water 19,Unit B Domestic Cold Water 17 | 192 | Level: Level 1 | 5482.7 | Level : Level 1
1184420 | Level 1 | Domestic Hot Water 20,Unit B Domestic Cold Water 18 | 193 | Level: TOF Footing | 1912.7 | Level : TOF Footing
1184705 | Level 1 | Domestic Hot Water 22,Unit B Domestic Cold Water 20 | 195 | Level: TOF Footing | 1912.7 | Level : TOF Footing
1184837 | Level 1 | Domestic Hot Water 21,Unit B Domestic Cold Water 19 | 196 | Level: TOF Footing | 1912.7 | Level : TOF Footing
1184935 | Level 1 | Domestic Hot Water 23,Unit B Domestic Cold Water 21 | 197 | Level: TOF Footing | 1912.7 | Level : TOF Footing
1185029 | Level 1 | Domestic Hot Water 24,Unit B Domestic Cold Water 22 | 198 | Level: TOF Footing | 1912.7 | Level : TOF Footing
1185239 | Level 1 | Domestic Hot Water 25,Unit B Domestic Cold Water 23 | 199 | Level: TOF Footing | 1912.7 | Level : TOF Footing
1185356 | Level 1 | Domestic Hot Water 26,Unit B Domestic Cold Water 24 | 200 | Level: TOF Footing | 1912.7 | Level : TOF Footing
1185542 | Level 1 | Domestic Hot Water 27,Unit B Domestic Cold Water 25 | 203 | Level: TOF Footing | 1912.7 | Level : TOF Footing
1185678 | Level 1 | Domestic Hot Water 28,Unit B Domestic Cold Water 26 | 204 | Level: TOF Footing | 1912.7 | Level : TOF Footing
1185713 | Level 1 | Domestic Hot Water 29,Unit B Domestic Cold Water 27 | 205 | Level: TOF Footing | 1912.7 | Level : TOF Footing
1185916 | Level 1 | Domestic Hot Water 30,Unit B Domestic Cold Water 28 | 206 | Level: TOF Footing | 1912.7 | Level : TOF Footing
1186041 | Level 1 | Domestic Hot Water 31,Unit B Domestic Cold Water 29 | 207 | Level: TOF Footing | 1912.7 | Level : TOF Footing
1186134 | Level 1 | Domestic Hot Water 32,Unit B Domestic Cold Water 30 | 208 | Level: TOF Footing | 1912.7 | Level : TOF Footing
1186225 | Level 1 | Domestic Hot Water 33,Unit B Domestic Cold Water 31 | 209 | Level: TOF Footing | 1912.7 | Level : TOF Footing
1186226 | Level 1 | Domestic Hot Water 34,Unit B Domestic Cold Water 32 | 210 | Level: TOF Footing | 1912.7 | Level : TOF Footing
1186550 | Level 1 | Domestic Hot Water 35,Unit B Domestic Cold Water 33 | 211 | Level: TOF Footing | 1912.7 | Level : TOF Footing
1186579 | Level 1 | Domestic Hot Water 35,Unit B Domestic Cold Water 34 | 212 | Level: TOF Footing | 1912.7 | Level : TOF Footing
1187095 | Level 1 | Domestic Hot Water 37,Unit B Domestic Cold Water 35 | 213 | Level: TOF Footing | 1912.7 | Level : TOF Footing
1187133 | Level 1 | Domestic Hot Water 38,Unit B Domestic Cold Water 36 | 214 | Level: TOF Footing | 1912.7 | Level : TOF Footing

# IfcFlowController: Lavatory Faucet (42)
Type - ElementType: Lavatory Faucet; Classification:  (UniFormat)
Text - OutletConnectionSize: 25; FlowCoefficient: 94; Finish: Chrome; WorkingPressure: 172000
Dimensions - Hot Water Connection Radius: 11.1125 mm; Cold Water Connection Radius: 11.1125 mm
Identity Data - URL: www.chicagofaucets.com; Specification: Chicago Faucets No. 802-VXKABCP, polished chrome plated solid cast brass body construction with integral 4" C-C spout and integral inlet shanks on 4" centers. ECAST&reg; construction with less than 0.25% lead content by weighted average. 2.2 GPM pressure compensating vandal resistant aerator outlet. 2-1/2" curved metal lever handles with eight point tapered broach and secured color coded index buttons with vandal resistant screws. Quarter-turn ceramic disc cartridge with square tapered broach feature to help facilitate handle removal. Inlet shanks contain standard 1/2" NPSM threaded inlets with coupling nuts for connection to 3/8" or 1/2" standard flexible risers. Mounting hardware included. This product meets ADA requirements and is tested and certified to industry standards: ASME A112.18.1, NSF 61 Sec. 9, and CSA B125.; Model: 802-VXKABCP; Manufacturer: N/A
Materials and Finishes - Ceramic Cartridge: Polished Chrome; Lock Nut: Brass; Cap: Polished Chrome; Coupling Nut: Brass; Lever Handle Assembly: Polished Chrome; Basin Cock Washer: Rough Chrome; V.R Softflo Aerator: Polished Chrome; Washer: Rough Chrome; Valve Body: Polished Chrome
Other - SpilloverLevel: 0; BodyMaterial: Chrome; ValveOperation: OTHER; CloseRating: 690000; ValveMechanism: BALL; WarrantyDurationParts: N/A; FaucetFunction: MIXED; Code Compliance: ASME A112.18.1M and CSA B125.1 and California Health and NSF 61, Section 9 and ADA ANSI/ICC A117.1 Safety Code 116875 (AB 1953-2006) and Vermont Bill S.152 and; WarrantyGuarantorLabor: N/A; Constituents: N/A; WarrantyGuarantorParts: N/A; ProductionYear: N/A; MeasuredFlowRate: 0.09; ReplacementCost: N/A; WarrantyDurationLabor: N/A; NominalLength: 0; Features: N/A; Grade: N/A; Size: 25; MountingOffset: 0; FaucetTopDescription: Cartridge; NominalWidth: 0; PercentageOpen: 9; ExpectedLife: N/A; Finish: Chrome; Shape: N/A; Material: N/A; WarrantyDescription: N/A; SustainabilityPerformance: N/A; NominalDepth: 1; CodePerformance: N/A; ModelLabel: N/A; ShowerHeadDescription: Fixed; TestPressure: 1724000; NominalHeight: 0; FaucetOperation: LEVERHANDLE; Reference: Type A - 1; ModelReference: N/A; HasGrabHandles: TRUE; ValvePattern: ALIGNED_2_PORT; Color: White; Aerator: 2.2 GPM (8.3L/min) Pressure Compensating Softflo Aerator; MixerControl: MANUAL; DrainSize: 0; MeasuredPressureDrop: 34473; AccessibilityPerformance: N/A; HasTray: TRUE; FaucetType: SINGLEOUTLETCOMBINATION; AssetAccountingType: FIXED; WarrantyStartDate: N/A; InstallationDate: N/A; BarCode: N/A; SerialNumber: N/A; AssetIdentifier: N/A; TagNumber: N/A
Constraints - Offset: 865 mm
Mechanical - System Name: Domestic Hot Water 1,Domestic Cold Water 1; System Classification: Domestic Hot Water,Domestic Cold Water
Phasing - Phase Created: New Construction
Name (Lavatory Faucet:Lavatory Faucet:Lavatory Faucet:...) | In | Host | Level | Mark
1190076 | Level 1 | Level : Level 1 | Level: Level 1 | 215
1191082 | Level 1 | Level : Level 1 | Level: Level 1 | 216
1191213 | Level 1 | Level : Level 1 | Level: Level 1 | 217
1191369 | Level 1 | Level : Level 1 | Level: Level 1 | 218
1191526 | Level 1 | Level : Level 1 | Level: Level 1 | 219
1191740 | Level 1 | Level : Level 1 | Level: Level 1 | 220
1191832 | Level 1 | Level : Level 1 | Level: Level 1 | 221
1191912 | Level 1 | Level : Level 1 | Level: Level 1 | 222
1192026 | Level 1 | Level : Level 1 | Level: Level 1 | 223
1192145 | Level 1 | Level : Level 1 | Level: Level 1 | 224
1192301 | Level 1 | Level : Level 1 | Level: Level 1 | 225
1192416 | Level 1 | Level : Level 1 | Level: Level 1 | 226
1192626 | Level 1 | Level : Level 1 | Level: Level 1 | 227
1192710 | Level 1 | Level : Level 1 | Level: Level 1 | 228
1192865 | Level 1 | Level : Level 1 | Level: Level 1 | 229
1193022 | Level 1 | Level : Level 1 | Level: Level 1 | 230
1193152 | Level 1 | Level : Level 1 | Level: Level 1 | 231
1193288 | Level 1 | Level : Level 1 | Level: Level 1 | 232
1193385 | Level 1 | Level : Level 1 | Level: Level 1 | 233
1193472 | Level 1 | Level : Level 1 | Level: Level 1 | 234
1193589 | Level 1 | Level : Level 1 | Level: Level 1 | 235
1193694 | Level 1 | Level : Level 1 | Level: Level 1 | 236
1193787 | Level 1 | Level : Level 1 | Level: Level 1 | 237
1193879 | Level 1 | Level : Level 1 | Level: Level 1 | 238
1193966 | Level 1 | Level : Level 1 | Level: Level 1 | 239
1194056 | Level 1 | Level : Level 1 | Level: Level 1 | 240
1194136 | Level 1 | Level : Level 1 | Level: Level 1 | 241
1194221 | Level 1 | Level : Level 1 | Level: Level 1 | 242
1194317 | Level 1 | Level : Level 1 | Level: Level 1 | 243
1194417 | Level 1 | Level : Level 1 | Level: Level 1 | 244
1194507 | Level 1 | Level : Level 1 | Level: Level 1 | 245
1194592 | Level 1 | Level : Level 1 | Level: Level 1 | 246
1194711 | Level 2 | Level : Level 2 | Level: Level 2 | 247
1194901 | Level 2 | Level : Level 2 | Level: Level 2 | 248
1195037 | Level 2 | Level : Level 2 | Level: Level 2 | 249
1195258 | Level 2 | Level : Level 2 | Level: Level 2 | 250
1195678 | Level 2 | Level : Level 2 | Level: Level 2 | 251
1195977 | Level 2 | Level : Level 2 | Level: Level 2 | 252
1196275 | Level 2 | Level : Level 2 | Level: Level 2 | 253
1196694 | Level 2 | Level : Level 2 | Level: Level 2 | 254
1196859 | Level 2 | Level : Level 2 | Level: Level 2 | 255
1196992 | Level 2 | Level : Level 2 | Level: Level 2 | 256

# IfcFlowController: Polished Chrome (3)
Type - ElementType: Polished Chrome; Classification: D2010710 Showers (UniFormat)
Material: Chrome - DELTA - Polished
Dimensions - Overall Width: 177.8 mm; Overall Depth: 244.673 mm; Overall Height: 680.175 mm
Plumbing - Hot Water Connection NPT: 0.0416667; Maximum Flow Rate: 0.00445602; Cold Water Connection NPT: 0.0416667
Materials and Finishes - Finish: Chrome - DELTA - Polished
Identity Data - Series: Monitor 17; Product Page URL: http://www.deltafaucet.com/bath/details/t17294.html; Model: T17294; URL: http://www.deltafaucet.com/; Manufacturer: DELTA; Version: 1; Description: Shower Trim; Assembly Description: Showers; CADworks URL: http://www.CADworks.net; OmniClass Number: 23.45.05.14.21.11; ADA Compliant: yes; Assembly Code: D2010710; OmniClass Title: Bath/Shower Units; Collection: Linden
Constraints - Default Elevation: 1130.3 mm; Cold Water Connection Radius: 0.0208333; Hot Water Connection Radius: 0.0208333; Distance from Control to Showerhead: 550 mm; Host: M_Shower Stall - Rectangular : 915 mmx915 mm - Public; Elevation: 1066 mm
Text - OutletConnectionSize: 25; Finish: Chrome; WorkingPressure: 310264; FlowCoefficient: 94
Mechanical - WFU: 0; HWFU: 0; CWFU: 0; System Classification: Domestic Hot Water,Domestic Cold Water; Flow Pressure: 0; System Name: Domestic Hot Water 1,Domestic Cold Water 1
Other - CodePerformance: N/A; SpilloverLevel: 0; ValveMechanism: NOTKNOWN; WarrantyGuarantorParts: N/A; ReplacementCost: N/A; Material: N/A; AccessibilityPerformance: N/A; Grade: N/A; Color: White; Constituents: N/A; MountingOffset: 0; FaucetFunction: MIXED; NominalWidth: 0; Features: N/A; ValvePattern: STRAIGHT_3_PORT; WarrantyGuarantorLabor: N/A; DrainSize: 0; WarrantyDurationLabor: N/A; FaucetOperation: LEVERHANDLE; CloseRating: 690000; MeasuredPressureDrop: 75842; Reference: Type A - 1; NominalLength: 0; WarrantyDurationParts: N/A; NominalDepth: 1; SustainabilityPerformance: N/A; TestPressure: 2068427; FaucetTopDescription: Cartridge; WarrantyDescription: N/A; ModelLabel: N/A; MeasuredFlowRate: 0.15; ExpectedLife: N/A; AssetAccountingType: FIXED; ValveOperation: OTHER; ProductionYear: N/A; PercentageOpen: 10; HasGrabHandles: TRUE; ShowerHeadDescription: Fixed; ModelReference: N/A; Shape: N/A; MixerControl: MANUAL; HasTray: TRUE; Finish: Chrome; BodyMaterial: Chrome; NominalHeight: 0; Size: 25; FaucetType: SINGLEOUTLETCOMBINATION; SerialNumber: N/A; InstallationDate: N/A; TagNumber: N/A; AssetIdentifier: N/A; BarCode: N/A; WarrantyStartDate: N/A
Phasing - Phase Created: New Construction
Name (Shower-Faucet_Trim-DELTA-Linden-T17294:Polished Chrome:Polished Chrome:...) | In | Mark | Schedule Level
1201690 | Level 2 | 258 | Level: Level 2
1202450 | Level 2 | 259 | Level: Level 2
1204268 | Level 1 | 260 | Level: Level 1

# IfcFlowFitting: 125 mm Strainer - 100 mm Drain (5)
In: Level 1
Type - ElementType: 125 mm Strainer - 100 mm Drain; PredefinedType: ENTRY; Classification:  (UniFormat)
Constraints - Default Elevation: 0 mm; Host: Pipe Types : Waste
Dimensions - Body Height: 92 mm; Pipe Diameter: 0.328084; Pipe Radius: 0.164042; Strainer Height: 83 mm; Body Diameter: 206 mm; Strainer Radius: 62.5 mm; Body Radius: 103 mm; Strainer Diameter: 125 mm
Identity Data - OmniClass Title: Drains (Wastes); Type Mark: FD; OmniClass Number: 23.45.55.21; Manufacturer: N/A
Mechanical - CWFU: 0; HWFU: 0; WFU: 4; System Name: Sanitary 1; System Classification: Sanitary; System Type: Piping System: Sanitary 1
Text - WorkingPressure: 0; FlowCoefficient: 0; OutletConnectionSize: 0; Finish: Chrome
Other - Reference: Type A - 1; NominalWidth: 0; Constituents: N/A; HasGrabHandles: TRUE; WarrantyGuarantorParts: N/A; WarrantyGuarantorLabor: N/A; Finish: Chrome; Shape: N/A; TestPressure: 0; Material: N/A; ProductionYear: N/A; Color: White; DrainSize: 0; Grade: N/A; CodePerformance: N/A; Radius 4: 46.875 mm; Radius 2: 85.3333 mm; SustainabilityPerformance: N/A; Features: N/A; NominalDepth: 1; Radius 5: 31.25 mm; Radius 6: 15.625 mm; ShowerHeadDescription: Fixed; MeasuredPressureDrop: 0; Radius 1: 67.6667 mm; AccessibilityPerformance: N/A; ExpectedLife: N/A; NominalHeight: 0; HasTray: TRUE; WarrantyDurationParts: N/A; ReplacementCost: N/A; Height 2: 18.4 mm; CloseRating: 0; WarrantyDescription: N/A; PercentageOpen: 0; FaucetTopDescription: Cartridge; MountingOffset: 0; AssetAccountingType: FIXED; Height 1: 46 mm; SpilloverLevel: 0; Size: 0; BodyMaterial: Brass; WarrantyDurationLabor: N/A; MeasuredFlowRate: 0; NominalLength: 0; Radius 3: 51.5 mm; ModelLabel: N/A; ModelReference: N/A; AssetIdentifier: N/A; TagNumber: N/A; WarrantyStartDate: N/A; InstallationDate: N/A; SerialNumber: N/A; BarCode: N/A
Phasing - Phase Created: New Construction
Name (M_Floor Drain - Round:125 mm Strainer - 100 mm Drain:125 mm Strainer - 100 mm Drain:...) | Schedule Level | Mark | Elevation (mm)
669201 | Level: Level 1 | 113 | 4511.26
669280 | Level: Level 1 | 114 | 4511.26
669363 | Level: Level 1 | 115 | 4511.26
669691 | Level: Level 2 | 116 | -58.7375
1083711 | Level: Level 1 | 157 | 4570

# IfcFlowFitting: 380 mm Strainer - 100 mm Drain (4)
In: Level 2
Type - ElementType: 380 mm Strainer - 100 mm Drain; PredefinedType: ENTRY; Classification:  (UniFormat)
Constraints - Default Elevation: 0 mm; Host: <not associated>
Dimensions - Pipe Radius: 0.164042; Pipe Diameter: 0.328084; Overall Diameter: 150 mm; Overall Radius: 75 mm
Identity Data - Manufacturer: N/A; OmniClass Number: 23.70.50.24.17; OmniClass Title: Siphonic Drains
Text - OutletConnectionSize: 0; TemperatureRange: 0; WorkingPressure: 0; Status: NEW
Other - OutletTemperatureRange: 0; PressureRating: 0; ImpellerDiameter: 0; IsWaterStorageHeater: TRUE; Material: N/A; SustainabilityPerformance: N/A; ModelLabel: N/A; NominalLength: 0; NetPositiveSuctionHead: 0; NominalPartLoadRatio: 0; WaterStorageCapacity: 0; ProductionYear: N/A; PressureRise: 0; Flowrate: 0; CoverWidth: 101; OperationalEfficiency: 0; NominalWidth: 0; MechanicalEfficiency: 0; Load: 0; ExpectedLife: N/A; FlowRateRange: 0; WarrantyDurationLabor: N/A; Constituents: N/A; ReplacementCost: N/A; PartialLoadEfficiencyCurves: 0; Grade: N/A; NominalEnergyConsumption: 0; AuxiliaryEnergyConsumption: 0; CodePerformance: N/A; CombustionTemperature: 0; Reference: Type H - 1; Power: 0; WaterInletTemperatureRange: 0; MountingOffset: 0; WarrantyGuarantorLabor: N/A; ModelReference: N/A; Size: 0; DrainSize: 0; OverallEfficiency: 0; RotationSpeed: 0; FlowResistanceRange: 0; HeatTransferSurfaceArea: 0; CoverLength: 0; WarrantyDurationParts: N/A; NominalEfficiency: 1.0; Features: N/A; PartLoadRatio: 0; EnergySourceConsumption: 0; AssetAccountingType: FIXED; WarrantyGuarantorParts: N/A; NominalHeight: 0; CombustionEfficiency: 0; ConnectionSize: 0; WarrantyDescription: N/A; PrimaryEnergyConsumption: 0; AccessibilityPerformance: N/A; Shape: N/A; HeatOutput: 0; NominalRotationSpeed: 0; SerialNumber: N/A; TagNumber: N/A; Schedule Level: Level: Level 1; WarrantyStartDate: N/A; AssetIdentifier: N/A; InstallationDate: N/A; BarCode: N/A
Mechanical - System Classification: Sanitary; System Name: Storm
Phasing - Phase Created: New Construction
Name (M_Roof Drain:380 mm Strainer - 100 mm Drain:380 mm Strainer - 100 mm Drain:...) | Offset (mm) | Elevation (mm) | Mark
727511 | -46.0375 | 9303.96 | OD
727522 | 0 | 9350 | RD
727559 | -46.0375 | 9303.96 | OD
727571 | 0 | 9350 | RD

# IfcFlowFitting: 380 mm Strainer - 150 mm Drain (10)
Type - ElementType: 380 mm Strainer - 150 mm Drain; PredefinedType: ENTRY; Classification:  (UniFormat)
Constraints - Default Elevation: 0 mm
Dimensions - Overall Diameter: 150 mm; Pipe Radius: 0.246063; Overall Radius: 75 mm; Pipe Diameter: 0.492126
Text - TemperatureRange: 0; OutletConnectionSize: 0; WorkingPressure: 0; Status: NEW
Identity Data - OmniClass Number: 23.70.50.24.17; Manufacturer: N/A; OmniClass Title: Siphonic Drains
Other - WarrantyGuarantorLabor: N/A; AssetAccountingType: FIXED; Load: 0; PartialLoadEfficiencyCurves: 0; Flowrate: 0; WarrantyGuarantorParts: N/A; WaterInletTemperatureRange: 0; PressureRise: 0; WaterStorageCapacity: 0; MountingOffset: 0; CoverWidth: 0; Material: N/A; AccessibilityPerformance: N/A; OperationalEfficiency: 0; OutletTemperatureRange: 0; NominalEfficiency: 1.0; ConnectionSize: 0; DrainSize: 0; FlowRateRange: 0; NominalPartLoadRatio: 0; PressureRating: 0; NominalRotationSpeed: 0; NominalWidth: 0; PartLoadRatio: 0; ModelReference: N/A; ProductionYear: N/A; CombustionEfficiency: 0; HeatOutput: 0; ImpellerDiameter: 0; Size: 0; CodePerformance: N/A; ReplacementCost: N/A; Grade: N/A; RotationSpeed: 0; CombustionTemperature: 0; EnergySourceConsumption: 0; OverallEfficiency: 0; PrimaryEnergyConsumption: 0; WarrantyDurationLabor: N/A; IsWaterStorageHeater: TRUE; CoverLength: 0; NominalLength: 0; ExpectedLife: N/A; AuxiliaryEnergyConsumption: 0; FlowResistanceRange: 0; NetPositiveSuctionHead: 0; MechanicalEfficiency: 0; HeatTransferSurfaceArea: 0; ModelLabel: N/A; NominalHeight: 0; SustainabilityPerformance: N/A; WarrantyDurationParts: N/A; NominalEnergyConsumption: 0; Power: 0; Shape: N/A; WarrantyDescription: N/A; Features: N/A; Reference: Type Z - 1; Constituents: N/A; InstallationDate: N/A; BarCode: N/A; TagNumber: N/A; WarrantyStartDate: N/A; AssetIdentifier: N/A; SerialNumber: N/A
Mechanical - System Classification: Sanitary
Phasing - Phase Created: New Construction
