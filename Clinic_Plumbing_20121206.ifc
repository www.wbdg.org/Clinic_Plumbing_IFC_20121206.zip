Properties of the parts of a building model (IFC2X3), part 2 of 29

# IfcFlowFitting: 380 mm Strainer - 150 mm Drain (10)
Name (M_Roof Drain:380 mm Strainer - 150 mm Drain:380 mm Strainer - 150 mm Drain:...) | In | Schedule Level | Offset (mm) | Elevation (mm) | Host | System Name | Mark
726902 | Level 2 | Level: Level 1 | -46.0375 | 9303.96 | <not associated> | Storm | OD
726998 | Level 2 | Level: Roof - Main | 0 | 100 | <not associated> | Storm | RD
727363 | Level 2 | Level: Level 1 | -46.0375 | 9303.96 | <not associated> | Storm | RD
727375 | Level 2 | Level: Level 1 | -46.0375 | 9303.96 | <not associated> | Storm | OD
727419 | Level 1 | Level: Level 1 | 0 | 4570 | Pipe Types : Storm | Storm | OD
727430 | Level 1 | Level: Level 1 | 0 | 4570 | <not associated> | Storm | RD
1074854 | Level 1 | Level: Level 2 | 0 | 0 | <not associated> | Storm | RD
1150681 | Level 2 | Level: Level 1 | 0 | 9350 | <not associated> | Sanitary 3 | RD
1150739 | Level 2 | Level: Level 1 | -46.0375 | 9303.96 | <not associated> | Sanitary 4 | OD
1151076 | Level 1 | Level: Level 1 | 0 | 4570 | Pipe Types : Storm |  | OD

# IfcFlowFitting: 380 mm Strainer - 25 mm Drain (16)
Type - ElementType: 380 mm Strainer - 25 mm Drain; PredefinedType: ENTRY; Classification:  (UniFormat)
Text - OutletConnectionSize: 25; TemperatureRange: 0; WorkingPressure: 0; Status: NEW
Constraints - Default Elevation: 0 mm
Dimensions - Pipe Diameter: 0.262467; Pipe Radius: 0.131234; Overall Diameter: 150 mm; Overall Radius: 75 mm
Identity Data - OmniClass Number: 23.70.50.24.17; Manufacturer: N/A; OmniClass Title: Siphonic Drains
Other - IsWaterStorageHeater: TRUE; Shape: N/A; ReplacementCost: N/A; WarrantyGuarantorLabor: N/A; ProductionYear: N/A; WarrantyDescription: N/A; OverallEfficiency: 0; PartLoadRatio: 0; WaterInletTemperatureRange: 0; OutletTemperatureRange: 0; Material: N/A; ModelReference: N/A; NominalRotationSpeed: 0; NominalHeight: 0; ImpellerDiameter: 0; ConnectionSize: 0; NominalLength: 330; PrimaryEnergyConsumption: 0; Power: 0; Grade: N/A; OperationalEfficiency: 0; Size: 0; MechanicalEfficiency: 0; AssetAccountingType: FIXED; WarrantyGuarantorParts: N/A; FlowRateRange: 0; Reference: Type L - 1; SustainabilityPerformance: N/A; CoverLength: 381; CombustionEfficiency: 0; PressureRating: 0; WarrantyDurationLabor: N/A; ExpectedLife: N/A; RotationSpeed: 0; PressureRise: 0; Load: 0; EnergySourceConsumption: 0; CoverWidth: 101; DrainSize: 0; AccessibilityPerformance: N/A; NominalEnergyConsumption: 0; NominalWidth: 25; CombustionTemperature: 0; NominalDepth: 25; NetPositiveSuctionHead: 0; MountingOffset: 0; WaterStorageCapacity: 0; Features: N/A; AuxiliaryEnergyConsumption: 0; CodePerformance: N/A; Constituents: N/A; NominalPartLoadRatio: 0; HeatOutput: 0; WarrantyDurationParts: N/A; Flowrate: 0; ModelLabel: N/A; HeatTransferSurfaceArea: 0; NominalEfficiency: 1.0; FlowResistanceRange: 0; PartialLoadEfficiencyCurves: 0; TagNumber: N/A; SerialNumber: N/A; WarrantyStartDate: N/A; InstallationDate: N/A; AssetIdentifier: N/A; BarCode: N/A
Mechanical - System Classification: Sanitary; System Name: Storm
Phasing - Phase Created: New Construction
Name (M_Roof Drain:380 mm Strainer - 25 mm Drain:380 mm Strainer - 25 mm Drain:...) | In | Mark | Schedule Level | Host | Offset (mm) | Elevation (mm)
727023 | Level 1 | OD | Level: Roof - Main | Pipe Types : Storm | 0 | -4680
727035 | Level 1 | RD | Level: Roof - Main | Pipe Types : Storm | 0 | -4680
727184 | Level 2 | RD | Level: Level 1 | <not associated> | -46.0375 | 6723.96
727209 | Level 2 | OD | Level: Level 1 | <not associated> | -46.0375 | 6723.96
727476 | Level 1 | RD | Level: Level 1 | Pipe Types : Storm | 0 | 4570
727487 | Level 1 | OD | Level: Level 1 | Pipe Types : Storm | 0 | 4570
1074177 | Level 1 | OD | Level: Level 2 | Pipe Types : Storm | 0 | 0
1074188 | Level 1 | RD | Level: Level 2 | Pipe Types : Storm | 0 | 0
1087018 | Level 2 | RD | Level: Level 1 | Linked Revit Model : Clinic_S.rvt | -46.0375 | 8010.46
1087064 | Level 2 | OD | Level: Level 1 | Linked Revit Model : Clinic_S.rvt | -46.0375 | 8010.46
1087332 | Level 2 | OD | Level: Level 1 | <not associated> | -46.0375 | 6723.96
1087343 | Level 2 | RD | Level: Level 1 | <not associated> | -46.0375 | 6723.96
1087420 | Level 2 | OD | Level: Level 1 | Linked Revit Model : Clinic_S.rvt | 0 | 8056.5
1087444 | Level 2 | RD | Level: Level 1 | Linked Revit Model : Clinic_S.rvt | 0 | 8056.5
1088355 | Level 2 | OD | Level: Roof - Main | Linked Revit Model : Clinic_S.rvt | -46.0375 | 73.9625
1088589 | Level 2 | RD | Level: Roof - Main | Linked Revit Model : Clinic_S.rvt | 0 | 120

# IfcFlowFitting: Cross - Generic (4)
Type - ElementType: Cross - Generic; Classification:  (UniFormat)
Text - TemperatureRange: 0; PressureRange: 0; InteriorRoughnessCoefficient: 4
Mechanical - Loss Method: 0; K Coefficient Table: Converging/Diverging Tee/Wye; Insulation Thickness: 0
Other - Lookup Table Name: M_Pipe Fitting - Generic.csv; Material: Material; WarrantyDurationParts: N/A; LossCoefficient: 0; CodePerformance: N/A; Color: White; Reference: Type A - 1; BendAngle: 0; ReplacementCost: N/A; AccessibilityPerformance: N/A; Constituents: N/A; Shape: N/A; FlowrateLeakage: 0; NominalHeight: 0; Features: N/A; WarrantyDurationLabor: N/A; ProductionYear: N/A; PressureClass: 0; AssetAccountingType: FIXED; NominalWidth: 0; NominalLength: 0; WarrantyGuarantorParts: N/A; Grade: N/A; ExpectedLife: N/A; ModelReference: N/A; WarrantyGuarantorLabor: N/A; ModelLabel: N/A; Size: Size; WarrantyDescription: N/A; FittingLossFactor: 0; SustainabilityPerformance: N/A; Angle 3: 90 deg; BendRadius: 0; BarCode: N/A; InstallationDate: N/A; Angle 5: 90 deg; WarrantyStartDate: N/A; TagNumber: N/A; JunctionRightRadius: 0; JunctionRightAngle: 0; JunctionLeftRadius: 0; AssetIdentifier: N/A; JunctionLeftAngle: 0; SerialNumber: N/A; Angle 4: 90 deg
Identity Data - OmniClass Number: 23.60.30.11.14; Manufacturer: N/A; OmniClass Title: Pipework Fittings
Graphics - Use Annotation Scale: yes
Dimensions - Angle 2: 90 deg; Angle 1: 90 deg
Phasing - Phase Created: New Construction
Name (M_Cross - Generic:Cross - Generic:Cross - Generic:...) | In | Fitting Outside Radius = Insulation Radius | Center to End Label = Center to End | System Classification | System Name | System Type | Tick Size | Size = Overall Size | Fitting Outside Diameter | Nominal Diameter | Nominal Radius | Level | Offset (mm) | Host | Mark
657219 | Level 1 | 0.0885417 | 0.130208 | Sanitary | Sanitary 1 | Piping System: Sanitary 1 | 0.0708333 | 50 mmø-50 mmø-50 mmø-50 mmø | 0.177083 | 0.164042 | 0.082021 | Level: Level 1 | 3100 | Level : Level 1 | 3617
667299 | Level 2 | 0.171875 | 0.213542 | Sanitary | Sanitary 1 | Piping System: Sanitary 1 | 0.1375 | 100 mmø-100 mmø-100 mmø-100 mmø | 0.34375 | 0.328084 | 0.164042 | Level: Level 2 | 232.932 | Level : Level 2 | 4763
678338 | TOF Footing | 0.0572917 | 0.0989583 | Domestic Cold Water | Domestic Cold Water 1 | Piping System: Domestic Cold Water 1 | 0.0458333 | 32 mmø-32 mmø-32 mmø-32 mmø | 0.114583 | 0.104987 | 0.0524934 | Level: Level 1 | -512.678 | Level : Level 1 | 4943
692404 | Level 1 | 0.171875 | 0.213542 | Sanitary | Sanitary 1 | Piping System: Sanitary 1 | 0.1375 | 100 mmø-100 mmø-100 mmø-100 mmø | 0.34375 | 0.328084 | 0.164042 | Level: Level 2 | -411 | Level : Level 2 | 6506

# IfcFlowFitting: Elbow - Generic (1654)
Type - ElementType: Elbow - Generic; Classification:  (UniFormat)
Other - JunctionLeftRadius: 0; TagNumber: N/A; BendRadius: 0; InstallationDate: N/A; JunctionLeftAngle: 0; BarCode: N/A; JunctionRightRadius: 0; AssetIdentifier: N/A; WarrantyStartDate: N/A; JunctionRightAngle: 0; SerialNumber: N/A; WarrantyDurationParts: N/A; WarrantyGuarantorLabor: N/A; ReplacementCost: N/A; WarrantyGuarantorParts: N/A; PressureClass: 0; WarrantyDurationLabor: N/A; FittingLossFactor: 0; AssetAccountingType: FIXED; Shape: N/A; AccessibilityPerformance: N/A; Size: Size; FlowrateLeakage: 0; ModelReference: N/A; Reference: Type A - 1; CodePerformance: N/A; WarrantyDescription: N/A; SustainabilityPerformance: N/A; NominalWidth: 0; Lookup Table Name: M_Pipe Fitting - Generic.csv; LossCoefficient: 0; Material: Material; ModelLabel: N/A; NominalLength: 0; NominalHeight: 0; BendAngle: 0; ExpectedLife: N/A; Features: N/A; ProductionYear: N/A; Grade: N/A; Constituents: N/A; Color: White
Graphics - Use Annotation Scale: yes
Mechanical - Insulation Thickness: 0; K Coefficient Table: Regular 45, 90 and 180 Elbow
Phasing - Phase Created: New Construction
Text - TemperatureRange: 0; PressureRange: 0; InteriorRoughnessCoefficient: 0
Identity Data - OmniClass Title: Pipework Fittings; Manufacturer: N/A; OmniClass Number: 23.60.30.11.14
Name (M_Elbow - Generic:Elbow - Generic:Elbow - Generic:...) | In | Offset (mm) | Level | Host | Fitting Outside Radius = Insulation Radius | Center Radius | Overall Size = Size | System Classification | Loss Method | System Type | System Name | Angle (deg) | Nominal Radius | Center to End | Fitting Outside Diameter | Tick Size | Nominal Diameter | Mark
625101 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 320
625103 | Level 1 | 500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 322
625128 | Level 1 | 500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 329
625188 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 342
625209 | Level 1 | 0 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.0677083 | 0.09375 | 0.0375 | 0.328084 | 345
625372 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 374
626388 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 454
627025 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 506
627931 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 44.1593 | 0.164042 | 0.0677083 | 0.09375 | 0.0375 | 0.328084 | 638
629675 | Level 1 | 0 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 80 mmø-80 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.131234 | 0.0677083 | 0.09375 | 0.0375 | 0.262467 | 863
630571 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.0677083 | 0.09375 | 0.0375 | 0.104987 | 1003
631201 | TOF Footing | -200 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.0677083 | 0.09375 | 0.0375 | 0.104987 | 1082
631338 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.0677083 | 0.09375 | 0.0375 | 0.104987 | 1107
631342 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90.4318 | 0.082021 | 0.0677083 | 0.09375 | 0.0375 | 0.164042 | 1110
632131 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 40 mmø-40 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0677083 | 0.09375 | 0.0375 | 0.131234 | 1211
633206 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 38.4429 | 0.082021 | 0.0381343 | 0.177083 | 0.0246965 | 0.164042 | 1398
633269 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 1403
633293 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 44.9363 | 0.131234 | 0.0624651 | 0.260417 | 0.0430794 | 0.262467 | 1410
633396 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 1418
633461 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 37.5707 | 0.0656168 | 0.0301167 | 0.135417 | 0.0184244 | 0.131234 | 1431
633568 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 1439
633601 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 86.3431 | 0.0524934 | 0.0732914 | 0.114583 | 0.0429976 | 0.104987 | 1443
633635 | Level 1 | 232.932 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 1450
633647 | Level 1 | 232.932 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 1452
633660 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 1454
633665 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 1458
633670 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 1462
633672 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 43.7354 | 0.164042 | 0.0773422 | 0.34375 | 0.0551847 | 0.328084 | 1464
633821 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 1471
633848 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 1476
633850 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 1477
633873 | Level 1 | 100 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 1480
633882 | Level 1 | 100 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 1482
634058 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 1488
634094 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 49.7269 | 0.0524934 | 0.0362039 | 0.114583 | 0.0212396 | 0.104987 | 1503
634162 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 44.1556 | 0.164042 | 0.0781638 | 0.34375 | 0.0557709 | 0.328084 | 1511
634212 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 1523
634235 | Level 1 | 231.963 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 1529
634263 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 44.1593 | 0.164042 | 0.0781709 | 0.34375 | 0.055776 | 0.328084 | 1536
634289 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 1544
634372 | Level 1 | 232.932 | Level: Level 1 | Level : Level 1 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.131234 | 0.151042 | 0.260417 | 0.104167 | 0.262467 | 1556
634442 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 1575
634487 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 51.8754 | 0.082021 | 0.0531986 | 0.177083 | 0.0344524 | 0.164042 | 1588
634525 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90.2934 | 0.082021 | 0.109936 | 0.177083 | 0.0711969 | 0.164042 | 1597
634527 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 1598
634558 | Level 1 | 0 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 1609
634600 | Level 1 | 0 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 1612
634604 | Level 1 | 0 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 1615
634605 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 1616
634607 | Level 1 | 232.932 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 1618
634651 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 1623
634735 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 1627
634778 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.131234 | 0.0625635 | 0.260417 | 0.0431472 | 0.262467 | 1636
634795 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 1645
634798 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 1647
634836 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 1663
634839 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 1665
635064 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 40.5146 | 0.082021 | 0.0403664 | 0.177083 | 0.026142 | 0.164042 | 1693
635065 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 1694
635096 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 89.9759 | 0.082021 | 0.109329 | 0.177083 | 0.0708036 | 0.164042 | 1699
635116 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 1706
635153 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90.0169 | 0.0656168 | 0.0885677 | 0.135417 | 0.0541826 | 0.131234 | 1717
635158 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 44.802 | 0.0656168 | 0.036496 | 0.135417 | 0.022327 | 0.131234 | 1721
635192 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 1726
635207 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 42.9601 | 0.0656168 | 0.0348419 | 0.135417 | 0.021315 | 0.131234 | 1728
635227 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 89.3376 | 0.0656168 | 0.0875239 | 0.135417 | 0.053544 | 0.131234 | 1730
635246 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 1732
635284 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 1741
635390 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 45.0059 | 0.082021 | 0.0453112 | 0.177083 | 0.0293444 | 0.164042 | 1771
635393 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 1773
635394 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 1774
635652 | TOF Footing | -200 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 1782
635698 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 43.4423 | 0.131234 | 0.0601713 | 0.260417 | 0.0414974 | 0.262467 | 1790
635744 | TOF Footing | -200 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 42.4557 | 0.0656168 | 0.0343926 | 0.135417 | 0.0210402 | 0.131234 | 1796
635838 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 34.5496 | 0.082021 | 0.0340137 | 0.177083 | 0.0220279 | 0.164042 | 1810
635869 | TOF Footing | -200 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 1819
635871 | TOF Footing | -200 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 43.635 | 0.0656168 | 0.0354455 | 0.135417 | 0.0216843 | 0.131234 | 1821
635880 | TOF Footing | -200 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 1824
635882 | TOF Footing | -200 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 1826
635970 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 1835
636001 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 1841
636002 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 1842
636339 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 44.8505 | 0.082021 | 0.0451375 | 0.177083 | 0.0292319 | 0.164042 | 1872
636401 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 35.0908 | 0.131234 | 0.0477548 | 0.260417 | 0.0329344 | 0.262467 | 1878
636424 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 35 | 0.082021 | 0.0344858 | 0.177083 | 0.0223337 | 0.164042 | 1885
636440 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 1888
636442 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 1890
636562 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 45.2656 | 0.082021 | 0.0456019 | 0.177083 | 0.0295326 | 0.164042 | 1907
636635 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 44.9859 | 0.082021 | 0.0452889 | 0.177083 | 0.0293299 | 0.164042 | 1910
636665 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 1917
636673 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 45.0141 | 0.082021 | 0.0453203 | 0.177083 | 0.0293503 | 0.164042 | 1924
636676 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 45.0479 | 0.082021 | 0.0453582 | 0.177083 | 0.0293749 | 0.164042 | 1926
636771 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.131234 | 0.0625635 | 0.260417 | 0.0431472 | 0.262467 | 1937
636860 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 29.9461 | 0.164042 | 0.051539 | 0.34375 | 0.0367737 | 0.328084 | 1947
636881 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 1954
637011 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 44.8542 | 0.164042 | 0.0795354 | 0.34375 | 0.0567496 | 0.328084 | 1972
637030 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 44.8825 | 0.164042 | 0.0795911 | 0.34375 | 0.0567893 | 0.328084 | 1975
637204 | TOF Footing | -479.363 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 1986
637209 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 45.0035 | 0.164042 | 0.0798292 | 0.34375 | 0.0569592 | 0.328084 | 1989
637222 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 1991
637263 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 1996
637399 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.131234 | 0.151042 | 0.260417 | 0.104167 | 0.262467 | 2007
637423 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.131234 | 0.151042 | 0.260417 | 0.104167 | 0.262467 | 2010
637427 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.131234 | 0.151042 | 0.260417 | 0.104167 | 0.262467 | 2013
637431 | Level 1 | 300 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 2016
637478 | Level 1 | 232.932 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2018
637500 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2026
637524 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 2033
637570 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 44.7201 | 0.164042 | 0.0792716 | 0.34375 | 0.0565613 | 0.328084 | 2041
637585 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 2045
637641 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 33.4062 | 0.082021 | 0.0328205 | 0.177083 | 0.0212552 | 0.164042 | 2056
637642 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 2057
637684 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2063
637742 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2075
637744 | Level 1 | 550 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 2077
637906 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 2090
637950 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2096
638123 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 45.0003 | 0.164042 | 0.079823 | 0.34375 | 0.0569548 | 0.328084 | 2100
638189 | Level 1 | 232.932 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2121
638190 | Level 1 | 232.932 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2122
638976 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 44.9031 | 0.082021 | 0.0451963 | 0.177083 | 0.02927 | 0.164042 | 2146
639162 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2168
639283 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 68.4565 | 0.082021 | 0.07441 | 0.177083 | 0.0481893 | 0.164042 | 2191
639361 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 2202
639369 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 2204
639371 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2206
639469 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 44.809 | 0.082021 | 0.0450912 | 0.177083 | 0.0292019 | 0.164042 | 2224
639564 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 2234
639605 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 2242
639660 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 2249
639661 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 2250
639663 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2252
639805 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2270
639828 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 2275
639829 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2276
639879 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 44.9225 | 0.082021 | 0.045218 | 0.177083 | 0.029284 | 0.164042 | 2290
639880 | TOF Footing | -200 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2291
639882 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2293
639935 | Level 1 | 0 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2296
639937 | Level 1 | 232.932 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2298
639941 | Level 1 | 0 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 2302
639943 | Level 1 | 0 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 2304
639951 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 2306
639955 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2309
640019 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 2315
640082 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 34.1055 | 0.082021 | 0.0335495 | 0.177083 | 0.0217273 | 0.164042 | 2325
640092 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2330
640111 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 2335
640113 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90.2999 | 0.082021 | 0.109949 | 0.177083 | 0.071205 | 0.164042 | 2337
640199 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2341
640214 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 41.7483 | 0.164042 | 0.0734886 | 0.34375 | 0.0524351 | 0.328084 | 2344
640324 | Level 1 | 232.932 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2352
640408 | Level 1 | 232.932 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2360
640410 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2362
640411 | Level 1 | 232.932 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2363
640545 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 44.5646 | 0.131234 | 0.0618922 | 0.260417 | 0.0426843 | 0.262467 | 2381
640564 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 2388
640566 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 2390
640604 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2394
640625 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 43.9151 | 0.082021 | 0.0440961 | 0.177083 | 0.0285575 | 0.164042 | 2401
640678 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 5 | Piping System: Sanitary 1 | Sanitary 1 | 44.9076 | 0.164042 | 0.0796405 | 0.34375 | 0.0568245 | 0.328084 | 2408
640771 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 2411
641092 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 2412
641093 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 2413
641110 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2414
641156 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2421
641200 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2430
641202 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 20 | 0.0656168 | 0.0156123 | 0.135417 | 0.00955104 | 0.131234 | 2432
641245 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2443
641266 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2451
641367 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2462
641369 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.0656168 | 0.0366752 | 0.135417 | 0.0224366 | 0.131234 | 2464
641384 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 2465
641479 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 2469
641512 | TOF Footing | -5070 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 2470
641608 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 2479
641618 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2483
641640 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2490
641808 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2499
641985 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2529
642008 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2531
642010 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2533
642016 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.0656168 | 0.0366752 | 0.135417 | 0.0224366 | 0.131234 | 2535
642031 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2537
642107 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.0656168 | 0.0366752 | 0.135417 | 0.0224366 | 0.131234 | 2556
642337 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2588
642343 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 2590
642373 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2598
642401 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2599
642462 | Level 1 | 3100 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2605
642478 | Level 1 | 3100 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 30 | 0.164042 | 0.051636 | 0.34375 | 0.036843 | 0.328084 | 2612
642607 | Level 1 | 3100 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2615
642631 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2618
642726 | Level 1 | 3100 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2626
642808 | Level 1 | 3100 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2655
642810 | Level 1 | 3100 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2657
643110 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 2692
643196 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 2694
643198 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2696
643218 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 2701
643240 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 2704
643291 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2709
643343 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2712
643345 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2714
643376 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2720
643388 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2724
643493 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2733
643502 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2734
643528 | Level 1 | 4000 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2736
643566 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.082021 | 0.0453046 | 0.177083 | 0.0293401 | 0.164042 | 2740
643592 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2745
643604 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.0656168 | 0.0366752 | 0.135417 | 0.0224366 | 0.131234 | 2749
643623 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2754
644000 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 45 | 0.164042 | 0.0798224 | 0.34375 | 0.0569544 | 0.328084 | 2779
644001 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2780
644019 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 2786
644108 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2803
644188 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2818
644346 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2825
644348 | Level 1 | 2900 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2827
644504 | Level 1 | 3000 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2840
644739 | Level 1 | 232.205 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 2845
644764 | Level 1 | 3000 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 2854
644917 | Level 1 | 600 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 2874
