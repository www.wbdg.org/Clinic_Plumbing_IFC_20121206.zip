Properties of the parts of a building model (IFC2X3), part 16 of 29

# IfcFlowFitting: Transition - Generic (1079)
Name (M_Transition - Generic:Transition - Generic:Transition - Generic:...) | In | Fitting Outside Radius 1 = Insulation Radius 1 | Width Offset | Visibility 3 | Visibility 1 | Max Fitting Outside Diameter 12 | Visibility 2 | Fitting Outside Radius 2 = Insulation Radius 2 | Height Offset | System Name | System Classification | System Type | Loss Method | Offset (mm) | Level | Host | Mark | Fitting Outside Diameter 2 | OffsetHeight | Length | Nominal Radius 1 | OffsetWidth | Nominal Radius 2 | Tick Size 2 | Tick Size 1 | Fitting Outside Diameter 1 | Size = Overall Size | Nominal Diameter 1 | Nominal Diameter 2
716448 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9242 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
716509 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1350 | Level: Level 2 | Level : Level 2 | 9244 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
716632 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9261 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
716713 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9263 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
716714 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9264 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
716758 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9268 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
716922 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9284 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
717106 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9309 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
717227 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9323 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
717258 | Level 1 | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9327 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
717362 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9336 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
717363 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9337 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
717385 | Level 1 | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9341 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
717496 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9352 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
717497 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9353 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
717592 | Level 1 | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9358 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
717697 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9367 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
717698 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9368 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
717727 | Level 1 | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9372 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
717825 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9387 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
717826 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9388 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
717860 | Level 1 | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.046875 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9389 | 0.09375 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0410105 | 0.0375 | 0.0458333 | 0.114583 | 32 mmø-25 mmø | 0.104987 | 0.082021
717872 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9393 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
718492 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9414 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
718493 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9415 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
718543 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9419 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
718619 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9431 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
718620 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9432 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
718672 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9436 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
718787 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9450 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
718788 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9451 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
718881 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9456 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
718980 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9467 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
718981 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9468 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
719003 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9472 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
719071 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9477 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
719072 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9478 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
719107 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1350 | Level: Level 2 | Level : Level 2 | 9479 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
719287 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1450 | Level: Level 2 | Level : Level 2 | 9496 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
719364 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1450 | Level: Level 2 | Level : Level 2 | 9502 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
719388 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1450 | Level: Level 2 | Level : Level 2 | 9510 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
719389 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1450 | Level: Level 2 | Level : Level 2 | 9511 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
719406 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1450 | Level: Level 2 | Level : Level 2 | 9516 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
719523 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1450 | Level: Level 2 | Level : Level 2 | 9527 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
719524 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1450 | Level: Level 2 | Level : Level 2 | 9528 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
719548 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 9529 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
719549 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 9530 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
719661 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 9534 | 0.0520833 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0246063 | 0.0208333 | 0.0541667 | 0.135417 | 40 mmø-15 mmø | 0.131234 | 0.0492126
719763 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 9544 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
719764 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 9545 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
724171 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 9757 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
997918 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1661.21 | Level: Level 2 | Level : Level 2 | 10002 | 0.09375 | 0.131234 | 0.0442708 | 0.131234 | 0.131234 | 0.082021 | 0.0375 | 0.0708333 | 0.177083 | 80 mmø-50 mmø | 0.262467 | 0.082021
1000542 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 10092 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
1054476 | Level 1 | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0677083 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 13400 | 0.135417 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0656168 | 0.0541667 | 0.0875 | 0.21875 | 65 mmø-40 mmø | 0.213255 | 0.131234
1056716 | Level 1 | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1453.96 | Level: Level 2 | Level : Level 2 | 13431 | 0.0729167 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0328084 | 0.0291667 | 0.0875 | 0.21875 | 65 mmø-20 mmø | 0.213255 | 0.0656168
1060904 | Level 1 | 0.0677083 | 10 | yes | no | 0.21875 | no | 0.109375 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 13435 | 0.21875 | 0.0656168 | 0.0546875 | 0.0656168 | 0.0656168 | 0.106627 | 0.0875 | 0.0541667 | 0.135417 | 65 mmø-40 mmø | 0.131234 | 0.213255
1060905 | Level 1 | 0.0677083 | 10 | yes | no | 0.21875 | no | 0.109375 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 13436 | 0.21875 | 0.0656168 | 0.0546875 | 0.0656168 | 0.0656168 | 0.106627 | 0.0875 | 0.0541667 | 0.135417 | 65 mmø-40 mmø | 0.131234 | 0.213255
1061794 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0260417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1623.11 | Level: Level 2 | Level : Level 2 | 13465 | 0.0520833 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0246063 | 0.0208333 | 0.1375 | 0.34375 | 100 mmø-15 mmø | 0.328084 | 0.0492126
1070309 | Level 2 | 0.255208 | 10 | no | no | 0.510417 | yes | 0.171875 | 10 | Hydronic Supply 1 | Hydronic Supply | Piping System: Hydronic Supply 1 | 1 | 3800 | Level: Level 2 | Level : Level 2 | 13717 | 0.34375 | 0.246063 | 0.127604 | 0.246063 | 0.246063 | 0.164042 | 0.1375 | 0.204167 | 0.510417 | 150 mmø-100 mmø | 0.492126 | 0.328084
1070336 | Level 2 | 0.255208 | 10 | no | no | 0.510417 | yes | 0.171875 | 10 | Hydronic Return 1 | Hydronic Return | Piping System: Hydronic Return 1 | 1 | 4000 | Level: Level 2 | Level : Level 2 | 13727 | 0.34375 | 0.246063 | 0.127604 | 0.246063 | 0.246063 | 0.164042 | 0.1375 | 0.204167 | 0.510417 | 150 mmø-100 mmø | 0.492126 | 0.328084
1070391 | Level 2 | 0.255208 | 10 | no | no | 0.510417 | yes | 0.171875 | 10 | Hydronic Supply 1 | Hydronic Supply | Piping System: Hydronic Supply 1 | 1 | 3800 | Level: Level 2 | Level : Level 2 | 13728 | 0.34375 | 0.246063 | 0.127604 | 0.246063 | 0.246063 | 0.164042 | 0.1375 | 0.204167 | 0.510417 | 150 mmø-100 mmø | 0.492126 | 0.328084
1070392 | Level 2 | 0.255208 | 10 | no | no | 0.510417 | yes | 0.171875 | 10 | Hydronic Return 1 | Hydronic Return | Piping System: Hydronic Return 1 | 1 | 4000 | Level: Level 2 | Level : Level 2 | 13729 | 0.34375 | 0.246063 | 0.127604 | 0.246063 | 0.246063 | 0.164042 | 0.1375 | 0.204167 | 0.510417 | 150 mmø-100 mmø | 0.492126 | 0.328084
1071563 | Level 1 | 0.255208 | 10 | no | no | 0.510417 | yes | 0.249959 | 10 | Hydronic Return 1 | Hydronic Return | Piping System: Hydronic Return 1 | 1 | 287 | Level: Level 1 | Level : Level 1 | 13746 | 0.499918 | 0.246063 | 0.127604 | 0.246063 | 0.246063 | 0.244751 | 0.199967 | 0.204167 | 0.510417 | 150 mmø-149 mmø | 0.492126 | 0.489501
1076203 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 0 | Level: Level 1 | Level : Level 1 | 13853 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
1076222 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 410.319 | Level: Level 1 | Level : Level 1 | 13859 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1076384 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 200 | Level: Level 1 | Level : Level 1 | 13879 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1076682 | Level 1 | 0.0677083 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 500 | Level: Level 1 | Level : Level 1 | 13889 | 0.177083 | 0.0656168 | 0.0442708 | 0.0656168 | 0.0656168 | 0.082021 | 0.0708333 | 0.0541667 | 0.135417 | 50 mmø-40 mmø | 0.131234 | 0.164042
1077099 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 400 | Level: Level 1 | Level : Level 1 | 13904 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
1077152 | Level 1 | 0.0572917 | 10 | yes | no | 0.135417 | no | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 635.088 | Level: Level 1 | Level : Level 1 | 13915 | 0.135417 | 0.0524934 | 0.0338542 | 0.0524934 | 0.0524934 | 0.0656168 | 0.0541667 | 0.0458333 | 0.114583 | 40 mmø-32 mmø | 0.104987 | 0.131234
1077174 | Level 1 | 0.0572917 | 10 | yes | no | 0.135417 | no | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 635.088 | Level: Level 1 | Level : Level 1 | 13921 | 0.135417 | 0.0524934 | 0.0338542 | 0.0524934 | 0.0524934 | 0.0656168 | 0.0541667 | 0.0458333 | 0.114583 | 40 mmø-32 mmø | 0.104987 | 0.131234
1077239 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 200 | Level: Level 1 | Level : Level 1 | 13930 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1077350 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 200 | Level: Level 1 | Level : Level 1 | 13941 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1077532 | Level 1 | 0.0572917 | 10 | yes | no | 0.135417 | no | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 635.088 | Level: Level 1 | Level : Level 1 | 13957 | 0.135417 | 0.0524934 | 0.0338542 | 0.0524934 | 0.0524934 | 0.0656168 | 0.0541667 | 0.0458333 | 0.114583 | 40 mmø-32 mmø | 0.104987 | 0.131234
1077596 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 200 | Level: Level 1 | Level : Level 1 | 13972 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
1077640 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 0 | Level: Level 1 | Level : Level 1 | 13980 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
1077846 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 550 | Level: Level 1 | Level : Level 1 | 13984 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1077946 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 200 | Level: Level 1 | Level : Level 1 | 13990 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1078049 | Level 1 | 0.0572917 | 10 | yes | no | 0.135417 | no | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 635.088 | Level: Level 1 | Level : Level 1 | 14002 | 0.135417 | 0.0524934 | 0.0338542 | 0.0524934 | 0.0524934 | 0.0656168 | 0.0541667 | 0.0458333 | 0.114583 | 40 mmø-32 mmø | 0.104987 | 0.131234
1078064 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 200 | Level: Level 1 | Level : Level 1 | 14008 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1078213 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 500 | Level: Level 1 | Level : Level 1 | 14019 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
1078232 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 610.319 | Level: Level 1 | Level : Level 1 | 14021 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1078439 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -500 | Level: Level 1 | Level : Level 1 | 14035 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
1078458 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 610.319 | Level: Level 1 | Level : Level 1 | 14037 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1078744 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -500 | Level: Level 1 | Level : Level 1 | 14051 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
1078763 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 610.319 | Level: Level 1 | Level : Level 1 | 14053 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1079065 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10.0059 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 300 | Level: Level 1 | Level : Level 1 | 14067 | 0.114583 | 0.0715593 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1079119 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 543.338 | Level: Level 1 | Level : Level 1 | 14078 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1079262 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 610.319 | Level: Level 1 | Level : Level 1 | 14104 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1079496 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 134.131 | Level: Level 1 | Level : Level 1 | 14110 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1079728 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 610.319 | Level: Level 1 | Level : Level 1 | 14113 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1080035 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -500 | Level: Level 1 | Level : Level 1 | 14155 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
1080054 | Level 1 | 0.0572917 | 10 | yes | no | 0.135417 | no | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 635.088 | Level: Level 1 | Level : Level 1 | 14161 | 0.135417 | 0.0524934 | 0.0338542 | 0.0524934 | 0.0524934 | 0.0656168 | 0.0541667 | 0.0458333 | 0.114583 | 40 mmø-32 mmø | 0.104987 | 0.131234
1080191 | TOF Footing | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -500 | Level: Level 1 | Level : Level 1 | 14169 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
1080346 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -500 | Level: Level 1 | Level : Level 1 | 14182 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
1080448 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -500 | Level: Level 1 | Level : Level 1 | 14196 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
1080544 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 610.319 | Level: Level 1 | Level : Level 1 | 14198 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1080842 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -500 | Level: Level 1 | Level : Level 1 | 14221 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
1080891 | TOF Footing | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 14233 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
1080918 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 200 | Level: Level 1 | Level : Level 1 | 14245 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1080991 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -350 | Level: Level 1 | Level : Level 1 | 14247 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
1081190 | TOF Footing | 0.0572917 | 10 | yes | no | 0.135417 | no | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -500 | Level: Level 1 | Level : Level 1 | 14256 | 0.135417 | 0.0524934 | 0.0338542 | 0.0524934 | 0.0524934 | 0.0656168 | 0.0541667 | 0.0458333 | 0.114583 | 40 mmø-32 mmø | 0.104987 | 0.131234
1081253 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 14263 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
1081476 | Level 2 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 14272 | 0.114583 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.0524934 | 0.0458333 | 0.104167 | 0.260417 | 80 mmø-32 mmø | 0.262467 | 0.104987
1081515 | Level 2 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 610.319 | Level: Level 2 | Level : Level 2 | 14278 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1081534 | Level 2 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 300 | Level: Level 2 | Level : Level 2 | 14288 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1081977 | Level 2 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 14301 | 0.114583 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.0524934 | 0.0458333 | 0.104167 | 0.260417 | 80 mmø-32 mmø | 0.262467 | 0.104987
1082009 | Level 2 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 610.319 | Level: Level 2 | Level : Level 2 | 14303 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1082130 | Level 2 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 14317 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
1082161 | Level 2 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 610.319 | Level: Level 2 | Level : Level 2 | 14319 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1082181 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 14329 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1082232 | Level 2 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 14337 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
1082350 | Level 2 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 610.319 | Level: Level 2 | Level : Level 2 | 14351 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1082679 | Level 2 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 14369 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
1082706 | Level 2 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 610.319 | Level: Level 2 | Level : Level 2 | 14371 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1082820 | Level 2 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 14385 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
1082839 | Level 2 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 610.319 | Level: Level 2 | Level : Level 2 | 14387 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1082912 | Level 2 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 14401 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
1082952 | Level 2 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 610.319 | Level: Level 2 | Level : Level 2 | 14403 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1083083 | Level 2 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 14419 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
1083125 | Level 2 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 610.319 | Level: Level 2 | Level : Level 2 | 14421 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1083237 | Level 2 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 14437 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
1083280 | Level 2 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 610.319 | Level: Level 2 | Level : Level 2 | 14439 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1083676 | Level 1 | 0.0677083 | 10 | yes | no | 0.34375 | no | 0.171875 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 14487 | 0.34375 | 0.0656168 | 0.0859375 | 0.0656168 | 0.0656168 | 0.164042 | 0.1375 | 0.0541667 | 0.135417 | 100 mmø-40 mmø | 0.131234 | 0.328084
1083749 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 14499 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
1083991 | Level 1 | 0.0677083 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 14516 | 0.177083 | 0.0656168 | 0.0442708 | 0.0656168 | 0.0656168 | 0.082021 | 0.0708333 | 0.0541667 | 0.135417 | 50 mmø-40 mmø | 0.131234 | 0.164042
1084313 | Level 2 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 14537 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
1084332 | Level 2 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 610.319 | Level: Level 2 | Level : Level 2 | 14539 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1084474 | Level 1 | 0.109375 | 10 | no | no | 0.21875 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 14560 | 0.0520833 | 0.106627 | 0.0546875 | 0.106627 | 0.106627 | 0.0246063 | 0.0208333 | 0.0875 | 0.21875 | 65 mmø-15 mmø | 0.213255 | 0.0492126
1084769 | Level 2 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 14578 | 0.114583 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.0524934 | 0.0458333 | 0.104167 | 0.260417 | 80 mmø-32 mmø | 0.262467 | 0.104987
1084788 | Level 2 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 610.319 | Level: Level 2 | Level : Level 2 | 14580 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1084936 | Level 2 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 14594 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
1084994 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 14598 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1085074 | Level 2 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 610.319 | Level: Level 2 | Level : Level 2 | 14613 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1085128 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 14617 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1085191 | Level 2 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 438.319 | Level: Level 2 | Level : Level 2 | 14619 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1085688 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 14635 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
1085892 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 14661 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1085912 | Level 2 | 0.0260417 | 10 | no | no | 0.0520833 | yes | 0.0208333 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 514.287 | Level: Level 2 | Level : Level 2 | 14669 | 0.0416667 | 0.0246063 | 0.0130208 | 0.0246063 | 0.0246063 | 0.0164042 | 0.0166667 | 0.0208333 | 0.0520833 | 15 mmø-10 mmø | 0.0492126 | 0.0328084
1086110 | Level 2 | 0.0260417 | 10 | no | no | 0.0520833 | yes | 0.0208333 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 500 | Level: Level 2 | Level : Level 2 | 14682 | 0.0416667 | 0.0246063 | 0.0130208 | 0.0246063 | 0.0246063 | 0.0164042 | 0.0166667 | 0.0208333 | 0.0520833 | 15 mmø-10 mmø | 0.0492126 | 0.0328084
1086489 | Level 1 | 0.0260417 | 10 | no | no | 0.0520833 | yes | 0.0208333 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 908.719 | Level: Level 1 | Level : Level 1 | 14704 | 0.0416667 | 0.0246063 | 0.0130208 | 0.0246063 | 0.0246063 | 0.0164042 | 0.0166667 | 0.0208333 | 0.0520833 | 15 mmø-10 mmø | 0.0492126 | 0.0328084
1086490 | Level 1 | 0.0260417 | 10 | no | no | 0.0520833 | yes | 0.0208333 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 908.719 | Level: Level 1 | Level : Level 1 | 14705 | 0.0416667 | 0.0246063 | 0.0130208 | 0.0246063 | 0.0246063 | 0.0164042 | 0.0166667 | 0.0208333 | 0.0520833 | 15 mmø-10 mmø | 0.0492126 | 0.0328084
1086770 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -500 | Level: Level 1 | Level : Level 1 | 14733 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
1086783 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 873 | Level: Level 1 | Level : Level 1 | 14737 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1086784 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 873 | Level: Level 1 | Level : Level 1 | 14738 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1096328 | TOF Footing | 0.0208333 | 10 | yes | no | 0.135417 | no | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -500 | Level: Level 1 | Level : Level 1 | 14848 | 0.135417 | 0.015625 | 0.0338542 | 0.015625 | 0.015625 | 0.0656168 | 0.0541667 | 0.0166667 | 0.0416667 | 40 mmø-10 mmø | 0.03125 | 0.131234
1096356 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -500 | Level: Level 1 | Level : Level 1 | 14861 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
1096780 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 200 | Level: Level 1 | Level : Level 1 | 14874 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
1097991 | TOF Footing | 0.0677083 | 10 | yes | no | 0.260417 | no | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -500 | Level: Level 1 | Level : Level 1 | 14880 | 0.260417 | 0.0656168 | 0.0651042 | 0.0656168 | 0.0656168 | 0.131234 | 0.104167 | 0.0541667 | 0.135417 | 80 mmø-40 mmø | 0.131234 | 0.262467
1098032 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -512.678 | Level: Level 1 | Level : Level 1 | 14884 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
1098064 | TOF Footing | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -495.216 | Level: Level 1 | Level : Level 1 | 14890 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1098218 | TOF Footing | 0.0677083 | 10 | yes | no | 0.260417 | no | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -500 | Level: Level 1 | Level : Level 1 | 14906 | 0.260417 | 0.0656168 | 0.0651042 | 0.0656168 | 0.0656168 | 0.131234 | 0.104167 | 0.0541667 | 0.135417 | 80 mmø-40 mmø | 0.131234 | 0.262467
1098422 | TOF Footing | 0.0677083 | 10 | yes | no | 0.260417 | no | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -326.987 | Level: Level 1 | Level : Level 1 | 14935 | 0.260417 | 0.0656168 | 0.0651042 | 0.0656168 | 0.0656168 | 0.131234 | 0.104167 | 0.0541667 | 0.135417 | 80 mmø-40 mmø | 0.131234 | 0.262467
1098443 | TOF Footing | 0.0677083 | 10 | yes | no | 0.260417 | no | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -501.1 | Level: Level 1 | Level : Level 1 | 14942 | 0.260417 | 0.0656168 | 0.0651042 | 0.0656168 | 0.0656168 | 0.131234 | 0.104167 | 0.0541667 | 0.135417 | 80 mmø-40 mmø | 0.131234 | 0.262467
1098603 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -376.869 | Level: Level 2 | Level : Level 2 | 14961 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1099023 | Level 1 | 0.0677083 | 10 | yes | no | 0.260417 | no | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -1688.2 | Level: Level 2 | Level : Level 2 | 14984 | 0.260417 | 0.0656168 | 0.0651042 | 0.0656168 | 0.0656168 | 0.131234 | 0.104167 | 0.0541667 | 0.135417 | 80 mmø-40 mmø | 0.131234 | 0.262467
1099212 | TOF Footing | 0.0677083 | 10 | yes | no | 0.260417 | no | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -500 | Level: Level 1 | Level : Level 1 | 15000 | 0.260417 | 0.0656168 | 0.0651042 | 0.0656168 | 0.0656168 | 0.131234 | 0.104167 | 0.0541667 | 0.135417 | 80 mmø-40 mmø | 0.131234 | 0.262467
1099327 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 327.744 | Level: Level 1 | Level : Level 1 | 15006 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
1109896 | Level 2 | 0.0677083 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 15022 | 0.177083 | 0.0656168 | 0.0442708 | 0.0656168 | 0.0656168 | 0.082021 | 0.0708333 | 0.0541667 | 0.135417 | 50 mmø-40 mmø | 0.131234 | 0.164042
1117851 | Level 2 | 0.0677083 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 15108 | 0.177083 | 0.0656168 | 0.0442708 | 0.0656168 | 0.0656168 | 0.082021 | 0.0708333 | 0.0541667 | 0.135417 | 50 mmø-40 mmø | 0.131234 | 0.164042
1118114 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 15133 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
1118115 | Level 1 | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.046875 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 15134 | 0.09375 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0410105 | 0.0375 | 0.0458333 | 0.114583 | 32 mmø-25 mmø | 0.104987 | 0.082021
1118142 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 15145 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
1118147 | Level 1 | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 15149 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
1118173 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 15154 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
1118178 | Level 1 | 0.0572917 | 10 | no | no | 0.114583 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 15158 | 0.0520833 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0524934 | 0.0246063 | 0.0208333 | 0.0458333 | 0.114583 | 32 mmø-15 mmø | 0.104987 | 0.0492126
1124054 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1350 | Level: Level 2 | Level : Level 2 | 15243 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
1124260 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1432.54 | Level: Level 2 | Level : Level 2 | 15270 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1124664 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 15308 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
1124778 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1350 | Level: Level 2 | Level : Level 2 | 15318 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1124779 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1350 | Level: Level 2 | Level : Level 2 | 15319 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1125752 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1350 | Level: Level 2 | Level : Level 2 | 15392 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
