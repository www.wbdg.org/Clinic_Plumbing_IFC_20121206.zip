Properties of the parts of a building model (IFC2X3), part 4 of 29

# IfcFlowFitting: Elbow - Generic (1654)
Name (M_Elbow - Generic:Elbow - Generic:Elbow - Generic:...) | In | Offset (mm) | Level | Host | Fitting Outside Radius = Insulation Radius | Center Radius | Overall Size = Size | System Classification | Loss Method | System Type | System Name | Angle (deg) | Nominal Radius | Center to End | Fitting Outside Diameter | Tick Size | Nominal Diameter | Mark
680561 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5157
680616 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5159
680647 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5164
680652 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5169
680672 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 5175
680754 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 5179
681154 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 5191
681238 | Level 1 | 232.932 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 5200
681269 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5207
681270 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5208
681296 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5218
681393 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5232
681431 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5233
681471 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5240
681507 | Level 1 | 676.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5247
681513 | Level 1 | 676.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5252
681560 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5260
681680 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5269
681711 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5272
681743 | Level 1 | 758.763 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5276
681859 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5291
681860 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5292
682196 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 5332
682219 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 5333
682237 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 5334
682285 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5340
682286 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5341
682309 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5352
682544 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5357
682576 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5360
682613 | Level 1 | 716.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5365
682618 | Level 1 | 716.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5370
682686 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 5377
682726 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 5380
682761 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5386
682762 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5387
682792 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5397
683402 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 5411
683404 | TOF Footing | -300 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 60 | 0.082021 | 0.0631477 | 0.177083 | 0.0408956 | 0.164042 | 5413
683526 | Level 1 | 232.932 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 5419
683548 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 5430
683574 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 5440
683605 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 5444
683635 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5450
683636 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5451
683659 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5462
683854 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 5474
683931 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5491
684002 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5498
684041 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5502
684075 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5506
684238 | Level 1 | 748.763 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5526
684448 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 5551
684481 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 5555
684512 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 5558
684542 | Level 1 | 806.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5562
684629 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5578
684677 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5580
684711 | Level 1 | 766.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5584
684807 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 5599
684816 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 5600
684850 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 5605
684876 | Level 1 | 711.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5609
684895 | Level 1 | 768.584 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5617
684993 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5636
685185 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5660
685202 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5661
685252 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5662
685260 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5668
685550 | Level 1 | 746.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5685
685555 | Level 1 | 746.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5690
685684 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.109375 | 0.130208 | 65 mmø-65 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.106627 | 0.130208 | 0.21875 | 0.0875 | 0.213255 | 5709
685699 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 5714
685776 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5727
685861 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 5734
685883 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5743
686018 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 5756
686066 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5766
686144 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5773
686151 | Level 1 | 688.2 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5774
686317 | Level 1 | 688.2 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5778
686367 | Level 1 | 1000 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 5781
686369 | Level 1 | 1000 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 5783
686401 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5789
686443 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5792
686473 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5798
686527 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 5809
686551 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 5810
686552 | Level 1 | 500 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 5811
686667 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5821
686672 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5826
686739 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 5837
686801 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5845
686880 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5854
686963 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5866
687004 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5869
687038 | Level 1 | 751.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5873
687043 | Level 1 | 751.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5878
687204 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5888
687213 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5889
687261 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5894
687646 | Level 1 | 600 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5940
687656 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5945
687658 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 5947
687700 | TOF Footing | -501.123 | Level: Level 1 | Level : Level 1 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 5954
687767 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 5962
687834 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 5964
687868 | Level 1 | 676.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5972
687870 | Level 1 | 676.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5974
687921 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 5982
687943 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 5983
687977 | Level 1 | 728.763 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5987
688024 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 5995
688078 | Level 1 | 725.231 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 5999
688139 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6012
688148 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6013
688174 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6014
688217 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6017
688295 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 6031
688334 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 6034
688383 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 6039
688416 | Level 1 | 746.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6043
688435 | Level 1 | 766.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6051
688558 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.130208 | 0.151042 | 80 mmø-80 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.131234 | 0.151042 | 0.260417 | 0.104167 | 0.262467 | 6066
688662 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 6075
688696 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 6077
688707 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 6080
688728 | Level 1 | 771.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6084
688756 | Level 1 | 771.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6097
688862 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6105
688918 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6115
688963 | Level 1 | 721.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6119
688968 | Level 1 | 721.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6124
689029 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 6132
689068 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 6134
689103 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 6140
689104 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 6141
689187 | Level 1 | 500 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6153
689292 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 6166
689293 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 6167
689390 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 6175
689428 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 6177
689429 | Level 1 | 500 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 6178
689557 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6186
689562 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6187
689601 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6190
689632 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6194
689637 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6199
689929 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6221
689965 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6224
689995 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6233
690060 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6243
690094 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6252
690207 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6260
690244 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6269
690312 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 6278
690313 | Level 1 | 500 | Level: Level 1 | Level : Level 1 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 6279
690463 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6287
690548 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6299
690576 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6304
690581 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6309
690657 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 6313
690767 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 6317
690810 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 6318
690892 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 6329
690915 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 6335
690916 | Level 1 | 688.244 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 6336
690996 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 6354
691019 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6362
691052 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6365
691079 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6369
691084 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6374
691134 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6383
691175 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6387
691180 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6392
691235 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6400
691260 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6404
691316 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 6415
691318 | Level 1 | 200 | Level: Level 1 | Level : Level 1 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 6417
691348 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6423
691376 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6424
691401 | Level 1 | 371.263 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6428
691508 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 6439
691577 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 6443
691924 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 6449
692004 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 6451
692048 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 6452
692149 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 6457
692151 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 6459
692166 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 6462
692188 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6474
692349 | Level 1 | -411 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 6501
692351 | Level 1 | -411 | Level: Level 2 | Level : Level 2 | 0.0572917 | 0.078125 | 32 mmø-32 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 90 | 0.0524934 | 0.078125 | 0.114583 | 0.0458333 | 0.104987 | 6503
692593 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6525
692654 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6528
692656 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6530
692683 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 6532
692708 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6540
692848 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 6556
692850 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 6558
692936 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 6563
692950 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 6565
693017 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 6589
693022 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 6590
693060 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 6593
693061 | Level 2 | 200 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 6594
693090 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 6598
693117 | TOF Footing | -512.678 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 6600
693154 | Level 1 | 3070 | Level: Level 1 | Level : Level 1 | 0.171875 | 0.192708 | 100 mmø-100 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.164042 | 0.192708 | 0.34375 | 0.1375 | 0.328084 | 6603
693254 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 6605
693263 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 6607
693373 | Level 2 | 300 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 6614
693447 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0677083 | 0.0885417 | 40 mmø-40 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0656168 | 0.0885417 | 0.135417 | 0.0541667 | 0.131234 | 6616
693505 | Level 2 | 300 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6624
693526 | Level 2 | 300 | Level: Level 2 | Level : Level 2 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 6627
694116 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.046875 | 0.0677083 | 25 mmø-25 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0410105 | 0.0677083 | 0.09375 | 0.0375 | 0.082021 | 6672
694126 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 6674
694181 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 6677
694303 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 6698
694494 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 6700
694495 | Level 2 | 300 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 6701
694665 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6723
694827 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0364583 | 0.0572917 | 20 mmø-20 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0328084 | 0.0572917 | 0.0729167 | 0.0291667 | 0.0656168 | 6740
695003 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6756
695260 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6793
695308 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 6797
695383 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 6815
695392 | Level 1 | -1500 | Level: Level 2 | Level : Level 2 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.082021 | 0.109375 | 0.177083 | 0.0708333 | 0.164042 | 6816
