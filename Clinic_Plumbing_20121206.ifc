Properties of the parts of a building model (IFC2X3), part 29 of 29

# IfcFlowSegment: Pipe Types:Waste:577155 (822)
Name (Pipe Types:Waste:...) | In | Invert Elevation (mm) | Diameter | Section | Area (mm2) | Overall Size = Size | Reference Level | Slope | Offset (mm) = Start Offset (mm) | End Offset (mm) | Outer Diameter | Inner Diameter | Length (mm) | Mark | Fixture Units | Relative Roughness
1098405 | Level 1 | -474.112 | 0.131234 | 209 | 59578.7 | 40 mmø | Level: Level 1 |  | 0 | -474.113 | 0.158333 | 0.134167 | 474.112 | 5413 | 2 | 16100
1098420 | Level 1 | -455.047 | 0.262467 | 894 | 27197.7 | 80 mmø | Level: Level 1 |  | -346.831 | -455.047 | 0.291667 | 0.255667 | 108.216 | 5414 | 0 | 30680
1098445 | Level 1 | -540.061 | 0.262467 | 894 | 81918.9 | 80 mmø | Level: Level 1 | 0 | -501.085 | -501.098 | 0.291667 | 0.255667 | 325.945 | 5416 | 0 | 30680
1098947 | Level 2 | 2842.84 | 0.262467 | 214 | 108687 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 432.452 | 5427 | 2 | 30680
1098953 | Level 2 | 2842.84 | 0.262467 | 214 | 25624.5 | 80 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.291667 | 0.255667 | 101.957 | 5428 | 2 | 30680
1099017 | Level 2 | 2908.79 | 0.131234 | 213 | 208754 | 40 mmø | Level: Level 2 |  | 0 | -1661.21 | 0.158333 | 0.134167 | 1661.21 | 5429 | 2 | 16100
1099206 | Level 1 | -473.013 | 0.131234 | 215 | 59440.5 | 40 mmø | Level: Level 1 |  | 0 | -473.013 | 0.158333 | 0.134167 | 473.013 | 5434 | 2 | 16100
1109894 | Level 2 | 2954.03 | 0.164042 | 695 | 279018 | 50 mmø | Level: Level 2 |  | -1615.97 | 160.313 | 0.197917 | 0.17225 | 1776.28 | 5440 | 0 | 20670
1110121 | Level 2 | 2830.67 | 0.328084 | 736 | 114470 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 364.37 | 5441 | 0 | 40260
1117829 | Level 2 | 2915.14 | 0.164042 | 900 | 285127 | 50 mmø | Level: Level 2 |  | -1654.86 | 160.312 | 0.197917 | 0.17225 | 1815.17 | 5458 | 0 | 20670
1117837 | Level 2 | 4743.75 | 0.164042 | 901 | 37636.9 | 50 mmø | Level: Level 2 | 0 | 200 | 200 | 0.197917 | 0.17225 | 239.604 | 5459 | 0 | 20670
1126762 | Level 2 | 2915.14 | 0.164042 | 651 | 97628.9 | 50 mmø | Level: Level 2 |  | -1654.86 | -1033.34 | 0.197917 | 0.17225 | 621.525 | 5571 | 0 | 20670
1126868 | Level 2 | 3543.75 | 0.164042 | 651 | 3933.41 | 50 mmø | Level: Level 2 | 0 | -1000 | -1000 | 0.197917 | 0.17225 | 25.0408 | 5572 | 0 | 20670
1127085 | Level 1 | 2879.55 | 0.131234 | 465 | 36757.5 | 40 mmø | Level: Level 1 | 0 | 2900 | 2900 | 0.158333 | 0.134167 | 292.507 | 5573 | 0 | 16100
1127139 | Level 1 | 2926.99 | 0.131234 | 465 | 5783.67 | 40 mmø | Level: Level 1 |  | 2973.01 | 2926.99 | 0.158333 | 0.134167 | 46.025 | 5574 | 0 | 16100
1127334 | Level 2 | 3375.14 | 0.164042 | 904 | 44928.7 | 50 mmø | Level: Level 2 |  | -908.838 | -1194.86 | 0.197917 | 0.17225 | 286.025 | 5578 | 0 | 20670
1127369 | Level 2 | 2921.49 | 0.164042 | 904 | 60785.9 | 50 mmø | Level: Level 2 |  | -1648.51 | -1261.54 | 0.197917 | 0.17225 | 386.975 | 5579 | 0 | 20670
1127397 | Level 2 | 2855.55 | 0.164042 | 903 | 92616.9 | 50 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.197917 | 0.17225 | 589.618 | 5580 | 0 | 20670
1127515 | Level 2 | 3315.55 | 0.164042 | 904 | 5234.68 | 50 mmø | Level: Level 2 | 0 | -1228.2 | -1228.2 | 0.197917 | 0.17225 | 33.325 | 5581 | 0 | 20670
1127565 | Level 2 | 3668.25 | 0.164042 | 904 | 5234.68 | 50 mmø | Level: Level 2 | 0 | -875.5 | -875.5 | 0.197917 | 0.17225 | 33.325 | 5584 | 0 | 20670
1127762 | Level 1 | 3539.55 | 0.131234 | 751 | 3270.4 | 40 mmø | Level: Level 1 | 0 | 3560 | 3560 | 0.158333 | 0.134167 | 26.025 | 5588 | 0 | 16100
1127830 | Level 1 | 3770.25 | 0.131234 | 751 | 3270.4 | 40 mmø | Level: Level 1 | 0 | 3790.7 | 3790.7 | 0.158333 | 0.134167 | 26.025 | 5589 | 0 | 16100
1129461 | Level 2 | 2830.67 | 0.328084 | 622 | 432576 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 1376.93 | 5606 | 0 | 40260
1129468 | Level 2 | 2830.67 | 0.328084 | 622 | 98385.3 | 100 mmø | Level: Level 2 | 0 | -1688.2 | -1688.2 | 0.375 | 0.3355 | 313.17 | 5607 | 0 | 40260
1207090 | Level 1 | -552.254 | 0.328084 | 905 | 780841 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 2485.49 | 5702 | 0 | 40260
1207107 | Level 1 | -552.254 | 0.328084 | 906 | 358014 | 100 mmø | Level: Level 1 | 0 | -501.123 | -501.123 | 0.375 | 0.3355 | 1139.59 | 5703 | 0 | 40260

# IfcFlowStorageDevice: 380 L, M_Water Heater:380 L:380 L:1061086
In: Level 2
Type - ElementType: 380 L; PredefinedType: PREFORMED; Classification:  (UniFormat)
Electrical - Loads - Apparent Load: 48437.6; Circuit Number: <unnamed>
Text - OutletConnectionSize: 0; TemperatureRange: 0; WorkingPressure: 206842; Status: NEW
Dimensions - Sanitary Radius: 0.0246063; Hot Water Radius: 0.0524934; Vent Radius: 0.164042; Hot Water Diameter: 0.104987; Vent Diameter: 0.328084; Water Heater Height: 1696 mm; Cold Water Diameter: 0.104987; Cold Water Radius: 0.0524934; Sanitary Diameter: 0.0492126; Water Heater Radius: 337 mm
Other - CombustionTemperature: 360; Reference: Type A - 1; ExpectedLife: N/A; ModelLabel: N/A; Flowrate: 0; PressureRise: 0; WarrantyDurationParts: N/A; DrainSize: 0; OperationalEfficiency: 0.9; OverallEfficiency: 0; AuxiliaryEnergyConsumption: 65; Power: 0; NominalEnergyConsumption: 70; Material: N/A; OperatingMode: OTHER; PartialLoadEfficiencyCurves: 0.62; WarrantyGuarantorParts: N/A; NominalHeight: 0; WarrantyDescription: N/A; NominalPartLoadRatio: 0.40; PartLoadRatio: 0.65; CoverWidth: 0; Load: 4396065; Grade: N/A; AssetAccountingType: FIXED; OutletTemperatureRange: 313; WaterInletTemperatureRange: 283; ModelReference: N/A; ImpellerDiameter: 0; Constituents: N/A; AccessibilityPerformance: N/A; NominalLength: 0; MechanicalEfficiency: 0; Features: N/A; WarrantyGuarantorLabor: N/A; EnergySource: ELECTRICITY; NetPositiveSuctionHead: 0; IsWaterStorageHeater: TRUE; CombustionEfficiency: 0.65; FlowResistanceRange: 0; NominalRotationSpeed: 0; PressureRating: 150000; Shape: N/A; CodePerformance: N/A; ConnectionSize: 0; SustainabilityPerformance: N/A; ReplacementCost: N/A; WaterStorageCapacity: 0.26; Size: 0; HeatOutput: 84348000; ProductionYear: N/A; WarrantyDurationLabor: N/A; MountingOffset: 0; PrimaryEnergyConsumption: 90; HeatTransferSurfaceArea: 125; CoverLength: 0; EnergySourceConsumption: 90; FlowRateRange: 0; RotationSpeed: 0; NominalWidth: 0; NominalEfficiency: 1.0; SerialNumber: N/A; InstallationDate: N/A; AssetIdentifier: N/A; WarrantyStartDate: N/A; BarCode: N/A; TagNumber: N/A
Electrical - Voltage: 2238.89; Number of Poles: 2; Load Classification: Appliance - Dwelling Unit
Identity Data - OmniClass Title: Storage Water Heaters; OmniClass Number: 23.65.35.11.11; Manufacturer: N/A; Mark: W.H.
Mechanical - System Name: Domestic Cold Water 1,Domestic Hot Water 1,Sanitary 1,Mechanical Exhaust Air 1; System Classification: Domestic Cold Water,Domestic Hot Water,Sanitary,Exhaust Air,Power
Phasing - Phase Created: New Construction
Constraints - Level: Level: Level 2; Offset: 0 mm; Host: Level : Level 2

# IfcFlowTerminal: 25 mm Flush Valve (3)
Type - ElementType: 25 mm Flush Valve; PredefinedType: URINAL; Classification:  (UniFormat)
Phasing - Phase Created: New Construction
Other - BarCode: N/A; AssetIdentifier: N/A; TagNumber: N/A; InstallationDate: N/A; WarrantyStartDate: N/A; SerialNumber: N/A; CloseRating: 0; NominalLength: 0; ReplacementCost: N/A; ProductionYear: N/A; WarrantyDurationLabor: N/A; Size: 0; WarrantyGuarantorLabor: N/A; WarrantyDescription: N/A; Shape: N/A; DrainSize: 0; ExpectedLife: N/A; Material: N/A; Height1: 365 mm; SpilloverLevel: 0; NominalWidth: 0; ModelReference: N/A; TestPressure: 0; AssetAccountingType: FIXED; NominalHeight: 0; Reference: Type A - 1; BodyMaterial: Brass; MeasuredPressureDrop: 0; ModelLabel: N/A; Finish: Chrome; AccessibilityPerformance: N/A; MountingOffset: 0; ShowerHeadDescription: Fixed; Constituents: N/A; HasTray: TRUE; PercentageOpen: 0; Grade: N/A; Half Urinal Width: 225 mm; Features: N/A; CodePerformance: N/A; WarrantyDurationParts: N/A; SustainabilityPerformance: N/A; NominalDepth: 1; HasGrabHandles: TRUE; FaucetTopDescription: Cartridge; MeasuredFlowRate: 0; WarrantyGuarantorParts: N/A; Color: White
Mechanical - System Classification: Sanitary,Domestic Cold Water; System Name: Sanitary 1,Domestic Cold Water 1; HWFU: 0; WFU: 4; CWFU: 10
Constraints - Elevation: 430 mm; Host: Linked Revit Model : Clinic_A.rvt; Default Elevation: 430 mm
Plumbing - Flow Pressure: 31522.7
Text - FlowCoefficient: 0; Finish: Chrome; UrinalType: TROUGH; OutletConnectionSize: 0; WorkingPressure: 0
Dimensions - Sanitary Radius: 0.082021; Sanitary Diameter: 0.164042; Cold Water Diameter: 0.0656168; Urinal Length: 445 mm; Urinal Width: 450 mm; Urinal Height: 660 mm; Cold Water Radius: 0.0328084
Identity Data - OmniClass Number: 23.45.05.21.11.21; OmniClass Title: Urinals; Manufacturer: N/A; Type Mark: P8150
Name (M_Urinal - Wall Hung:25 mm Flush Valve:25 mm Flush Valve:...) | In | Schedule Level | Mark
621238 | Level 1 | Level: Level 1 | 59
651923 | Level 2 | Level: Level 2 | 95
652788 | Level 2 | Level: Level 2 | 104

# IfcFlowTerminal: 455 mmx455 mm - Private (36)
Type - ElementType: 455 mmx455 mm - Private; PredefinedType: SINK; Classification:  (UniFormat)
Constraints - Default Elevation: 0 mm; Host: Linked Revit Model : Clinic_A.rvt
Dimensions - Hot Water Radius: 0.0246063; Sink Width: 455 mm; Sanitary Radius: 0.0656168; Cold Water Diameter: 0.0492126; Hot Water Diameter: 0.0492126; Cold Water Radius: 0.0246063; Sink Length: 455 mm; Sink Depth: 203 mm; Sanitary Diameter: 0.131234
Mechanical - HWFU: 1; WFU: 2; CWFU: 1; System Classification: Sanitary; System Name: Sanitary 1; System Type: Piping System: Sanitary 1
Identity Data - OmniClass Number: 23.45.05.14.14; OmniClass Title: Sinks/Lavatories; Manufacturer: N/A
Other - AssetAccountingType: FIXED; Shape: N/A; FaucetTopDescription: Cartridge; WarrantyDurationLabor: N/A; DrainSize: 40; SpilloverLevel: 0; SinkType: BELFAST; MeasuredPressureDrop: 0; BodyMaterial: Brass; AccessibilityPerformance: N/A; NominalDepth: 225; Features: N/A; Size: 0; ModelReference: N/A; ModelLabel: N/A; Color: White; Reference: Type A - 1; Material: N/A; CodePerformance: N/A; ProductionYear: N/A; ShowerHeadDescription: Fixed; WarrantyDurationParts: N/A; ExpectedLife: N/A; WarrantyDescription: N/A; TestPressure: 0; NominalWidth: 455; Mounting: COUNTERTOP; ReplacementCost: N/A; CloseRating: 0; Finish: Chrome; HasGrabHandles: TRUE; MountingOffset: 13; SustainabilityPerformance: N/A; NominalLength: 455; Grade: N/A; HasTray: TRUE; NominalHeight: 0; MeasuredFlowRate: 0; Constituents: N/A; WarrantyGuarantorParts: N/A; PercentageOpen: 0; WarrantyGuarantorLabor: N/A; TagNumber: N/A; AssetIdentifier: N/A; BarCode: N/A; InstallationDate: N/A; SerialNumber: N/A; WarrantyStartDate: N/A
Text - OutletConnectionSize: 0; WorkingPressure: 0; FlowCoefficient: 0; Finish: Chrome
Plumbing - Flow Pressure: 16812.2
Phasing - Phase Created: New Construction
Name (M_Sink - Island - Single1:455 mmx455 mm - Private:455 mmx455 mm - Private:...) | In | Schedule Level | Mark | Elevation (mm)
1076089 | Level 1 | Level: Level 2 | 126 | -3670
1076732 | Level 1 |  | 128 | 0
1076958 | Level 1 | Level: Level 2 | 129 | -3670
1076976 | Level 1 | Level: Level 2 | 130 | -3670
1077454 | Level 1 | Level: Level 2 | 131 | -3670
1077696 | Level 1 | Level: Level 2 | 132 | -3670
1077715 | Level 1 | Level: Level 2 | 133 | -3670
1078122 | Level 1 | Level: Level 2 | 134 | -3670
1078367 | Level 1 | Level: Level 2 | 135 | -3670
1078558 | Level 1 | Level: Level 2 | 136 | -3670
1078607 | Level 1 | Level: Level 2 | 137 | -3670
1078629 | Level 1 | Level: Level 2 | 138 | -3670
1079325 | Level 1 | Level: Level 2 | 139 | -3670
1079387 | Level 1 | Level: Level 2 | 140 | -3670
1079898 | Level 1 | Level: Level 2 | 141 | -3670
1080102 | Level 1 | Level: Level 2 | 142 | -3670
1080459 | Level 1 | Level: Level 2 | 143 | -3670
1080682 | Level 1 | Level: Level 2 | 144 | -3670
1081121 | Level 1 | Level: Level 1 | 145 | 900
1081410 | Level 2 | Level: Level 1 | 146 | 5470
1081598 | Level 2 | Level: Level 1 | 147 | 5470
1081614 | Level 2 | Level: Level 1 | 148 | 5470
1081630 | Level 2 | Level: Level 1 | 149 | 5470
1081649 | Level 2 | Level: Level 1 | 150 | 5470
1081665 | Level 2 | Level: Level 1 | 151 | 5470
1081690 | Level 2 | Level: Level 1 | 152 | 5470
1081712 | Level 2 | Level: Level 1 | 153 | 5470
1081824 | Level 2 | Level: Level 1 | 154 | 5470
1081840 | Level 2 | Level: Level 1 | 155 | 5470
1083409 | Level 2 | Level: Level 2 | 156 | 900
1083863 | Level 2 | Level: Level 1 | 158 | 5470
1084116 | Level 2 | Level: Level 1 | 159 | 5470
1084132 | Level 2 | Level: Level 1 | 160 | 5470
1084625 | Level 2 | Level: Level 1 | 161 | 5470
1084638 | Level 2 | Level: Level 1 | 162 | 5470
1084700 | Level 2 | Level: Level 1 | 163 | 5470

# IfcFlowTerminal: 510 mmx455 mm (6)
Type - ElementType: 510 mmx455 mm; PredefinedType: SINK; Classification:  (UniFormat)
Mechanical - WFU: 2; HWFU: 2.25; CWFU: 2.25; System Classification: Domestic Cold Water,Domestic Hot Water,Sanitary
Dimensions - Hot Water Diameter: 0.0492126; Sink Length: 510 mm; Cold Water Radius: 0.0246063; Hot Water Radius: 0.0246063; Faucet Height: 346 mm; Sink Width: 455 mm; Sink Depth: 203 mm; Sanitary Radius: 0.0656168; Cold Water Diameter: 0.0492126; Sanitary Diameter: 0.131234
Identity Data - Manufacturer: N/A; OmniClass Number: 23.45.05.14.14; OmniClass Title: Sinks/Lavatories; Type Mark: P4700
Text - OutletConnectionSize: 0; WorkingPressure: 0; Finish: Chrome; FlowCoefficient: 0
Other - Color: White; SustainabilityPerformance: N/A; ModelLabel: N/A; Constituents: N/A; WarrantyDescription: N/A; Size: 0; WarrantyGuarantorParts: N/A; MeasuredPressureDrop: 0; SpilloverLevel: 0; AssetAccountingType: FIXED; NominalDepth: 225; MountingOffset: 13; PercentageOpen: 0; HasTray: TRUE; Material: N/A; ReplacementCost: N/A; ShowerHeadDescription: Fixed; Features: N/A; Shape: N/A; Grade: N/A; NominalHeight: 0; BodyMaterial: Brass; NominalLength: 510; NominalWidth: 455; ProductionYear: N/A; CodePerformance: N/A; ExpectedLife: N/A; WarrantyDurationParts: N/A; SinkType: BELFAST; CloseRating: 0; TestPressure: 0; AccessibilityPerformance: N/A; MeasuredFlowRate: 0; FaucetTopDescription: Cartridge; HasGrabHandles: TRUE; ModelReference: N/A; WarrantyDurationLabor: N/A; WarrantyGuarantorLabor: N/A; Mounting: COUNTERTOP; Reference: Type A - 1; Finish: Chrome; DrainSize: 40; SerialNumber: N/A; InstallationDate: N/A; WarrantyStartDate: N/A; BarCode: N/A; AssetIdentifier: N/A; TagNumber: N/A
Constraints - Offset: 0 mm
Plumbing - Flow Pressure: 16812.2
Phasing - Phase Created: New Construction
Name (M_Sink - Work:510 mmx455 mm:510 mmx455 mm:...) | In | Mark | System Name | Host | Level
1097731 | Level 1 | 170 | Domestic Cold Water 1,Domestic Hot Water 1,Sanitary 2 | Level : Level 1 | Level: Level 1
1098106 | Level 1 | 171 | Domestic Cold Water 1,Domestic Hot Water 1,Sanitary 1 | Level : Level 1 | Level: Level 1
1098322 | Level 1 | 172 | Domestic Cold Water 1,Domestic Hot Water 1,Sanitary 1 | Level : Level 1 | Level: Level 1
1098534 | Level 2 | 173 | Domestic Cold Water 1,Domestic Hot Water 1,Sanitary 1 | Level : Level 2 | Level: Level 2
1098845 | Level 2 | 174 | Domestic Cold Water 1,Domestic Hot Water 1,Sanitary 1 | Level : Level 2 | Level: Level 2
1099160 | Level 1 | 175 | Domestic Cold Water 1,Domestic Hot Water 1,Sanitary 1 | Level : Level 1 | Level: Level 1

# IfcFlowTerminal: 535 mmx485 mm - Public (42)
Type - ElementType: 535 mmx485 mm - Public; PredefinedType: SINK; Classification:  (UniFormat)
Mechanical - System Classification: Sanitary; System Type: Piping System: Sanitary 1; System Name: Sanitary 1; WFU: 1; HWFU: 1.5; CWFU: 1.5
Constraints - Elevation: 865 mm; Default Elevation: 865 mm
Other - BarCode: N/A; AssetIdentifier: N/A; WarrantyStartDate: N/A; SerialNumber: N/A; InstallationDate: N/A; TagNumber: N/A; TestPressure: 0; Grade: N/A; Size: 0; PercentageOpen: 0; NominalDepth: 152; HasGrabHandles: TRUE; Finish: Chrome; DrainSize: 32; Reference: Type A - 1; WarrantyDurationParts: N/A; Color: White; MeasuredFlowRate: 0; ModelReference: N/A; Shape: N/A; MeasuredPressureDrop: 0; Features: N/A; CodePerformance: N/A; WarrantyGuarantorLabor: N/A; Half Lavatory Length: 267.5 mm; WarrantyGuarantorParts: N/A; BodyMaterial: Brass; Mounting: VANITY; Half Oval Short Axis Length: 159 mm; ShowerHeadDescription: Fixed; Constituents: N/A; Half Oval Long Axis Length: 203 mm; NominalWidth: 485; ReplacementCost: N/A; WarrantyDescription: N/A; ModelLabel: N/A; CloseRating: 0; ProductionYear: N/A; NominalLength: 535; AssetAccountingType: FIXED; MountingOffset: 19; WarrantyDurationLabor: N/A; ExpectedLife: N/A; WashHandBasinType: DENTALCUSPIDOR; SpilloverLevel: 0; Material: N/A; Half Oval Long Axis Length 1: 199.825 mm; NominalHeight: 0; FaucetTopDescription: Cartridge; HasTray: TRUE; AccessibilityPerformance: N/A; Half Oval Short Axis Length 1: 155.825 mm; SustainabilityPerformance: N/A
Phasing - Phase Created: New Construction
Plumbing - Flow Pressure: 16812.2
Text - OutletConnectionSize: 0; FlowCoefficient: 0; WorkingPressure: 0; Finish: Chrome
Identity Data - OmniClass Number: 23.45.05.14.14; Type Mark: P3070; Manufacturer: N/A; OmniClass Title: Sinks/Lavatories
Dimensions - Sanitary Radius: 0.0524934; Lavatory Length: 535 mm; Oval Short Axis Length: 318 mm; Hot Water Diameter: 0.0492126; Hot Water Radius: 0.0246063; Lavatory Height: 152 mm; Cold Water Radius: 0.0246063; Lavatory Width: 485 mm; Cold Water Diameter: 0.0492126; Sanitary Diameter: 0.104987; Oval Long Axis Length: 406 mm
Name (M_Lavatory - Oval:535 mmx485 mm - Public:535 mmx485 mm - Public:...) | In | Host | Schedule Level | Mark
605118 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 1
607299 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 10
608074 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 11
608175 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 12
608287 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 13
608745 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 16
609286 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 19
610875 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 22
611200 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 24
611389 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 25
612255 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 26
612784 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 28
612872 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 29
613486 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 31
613677 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 32
613952 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 34
614010 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 35
614626 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 36
615041 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 37
615452 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 39
615478 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 40
617247 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 46
618296 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 49
618322 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 50
619429 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 53
621460 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 60
621504 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 61
621629 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 62
622232 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 65
624609 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 66
643128 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 69
649233 | Level 2 | Linked Revit Model : Clinic_A.rvt | Level: Level 2 | 72
650031 | Level 2 | Linked Revit Model : Clinic_A.rvt | Level: Level 2 | 80
651709 | Level 2 | <not associated> | Level: Level 2 | 94
652235 | Level 2 | Linked Revit Model : Clinic_A.rvt | Level: Level 2 | 99
652493 | Level 2 | Linked Revit Model : Clinic_A.rvt | Level: Level 2 | 101
653370 | Level 2 | Grid : 2 | Level: Level 2 | 109
653399 | Level 2 | Linked Revit Model : Clinic_A.rvt | Level: Level 2 | 110
655837 | Level 2 | Linked Revit Model : Clinic_A.rvt | Level: Level 2 | 112
683407 | Level 1 | Linked Revit Model : Clinic_A.rvt | Level: Level 1 | 120
698241 | Level 2 | Linked Revit Model : Clinic_A.rvt | Level: Level 2 | 122
698631 | Level 2 | <not associated> | Level: Level 2 | 123

# IfcFlowTerminal: 710 mmx710 mm, M_Sink - Mop:710 mmx710 mm:710 mmx710 mm:653536
In: Level 2
Type - ElementType: 710 mmx710 mm; PredefinedType: SINK; Classification:  (UniFormat)
Identity Data - Type Mark: P4700; OmniClass Title: Sinks/Lavatories; OmniClass Number: 23.45.05.14.14; Manufacturer: N/A; Mark: 111
Other - WashHandBasinType: DENTALCUSPIDOR; CloseRating: 0; Size: 0; CodePerformance: N/A; Color: White; ShowerHeadDescription: Fixed; Mounting: VANITY; ProductionYear: N/A; Shape: N/A; WarrantyGuarantorLabor: N/A; Constituents: N/A; NominalWidth: 710; WarrantyDurationParts: N/A; PercentageOpen: 0; WarrantyGuarantorParts: N/A; Material: N/A; MeasuredPressureDrop: 0; Grade: N/A; Features: N/A; AssetAccountingType: FIXED; HasGrabHandles: TRUE; NominalLength: 710; HasTray: TRUE; MountingOffset: 19; WarrantyDescription: N/A; DrainSize: 40; MeasuredFlowRate: 0; NominalDepth: 152; Reference: Type A - 1; BodyMaterial: Brass; NominalHeight: 0; TestPressure: 0; ExpectedLife: N/A; WarrantyDurationLabor: N/A; Finish: Chrome; ReplacementCost: N/A; SpilloverLevel: 0; FaucetTopDescription: Cartridge; Half Sink Length: 355 mm; AccessibilityPerformance: N/A; ModelLabel: N/A; SustainabilityPerformance: N/A; ModelReference: N/A; Half Sink Width: 355 mm; TagNumber: N/A; SerialNumber: N/A; AssetIdentifier: N/A; InstallationDate: N/A; WarrantyStartDate: N/A; BarCode: N/A
Mechanical - CWFU: 0; WFU: 2; HWFU: 0; System Type: Piping System: Sanitary 1; System Name: Sanitary 1; System Classification: Sanitary
Dimensions - Sink Length: 710 mm; Sanitary Radius: 0.082021; Sink Width: 710 mm; Sanitary Diameter: 0.164042
Text - FlowCoefficient: 0; Finish: Chrome; OutletConnectionSize: 0; WorkingPressure: 0
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Level: Level: Level 2; Host: Level : Level 2

# IfcFlowTerminal: 915 mmx915 mm - Public (3)
Type - ElementType: 915 mmx915 mm - Public; PredefinedType: SHOWER; Classification:  (UniFormat)
Constraints - Offset: 0 mm
Phasing - Phase Created: New Construction
Other - TagNumber: N/A; InstallationDate: N/A; SerialNumber: N/A; AssetIdentifier: N/A; WarrantyStartDate: N/A; BarCode: N/A; Features: N/A; NominalWidth: 915; MeasuredPressureDrop: 0; NominalHeight: 0; SpilloverLevel: 0; WarrantyDurationLabor: N/A; PercentageOpen: 0; WarrantyGuarantorParts: N/A; Constituents: N/A; NominalLength: 915; Reference: Type A - 1; NominalDepth: 1800; ExpectedLife: N/A; Color: White; Length 1: 38.1 mm; Grade: N/A; FaucetTopDescription: Cartridge; Half Door Width: 286 mm; Finish: Chrome; SustainabilityPerformance: N/A; AssetAccountingType: FIXED; HasTray: TRUE; WarrantyDescription: N/A; ShowerHeadDescription: Fixed; Material: N/A; Shape: N/A; AccessibilityPerformance: N/A; Angle: 45 deg; WarrantyGuarantorLabor: N/A; ProductionYear: N/A; BodyMaterial: Brass; HasGrabHandles: TRUE; CloseRating: 0; WarrantyDurationParts: N/A; ModelReference: N/A; Size: 0; DrainSize: 40; CodePerformance: N/A; ReplacementCost: N/A; MeasuredFlowRate: 0; TestPressure: 0; ModelLabel: N/A; MountingOffset: 0
Mechanical - System Classification: Sanitary,Domestic Cold Water,Domestic Hot Water; System Name: Sanitary 1,Domestic Cold Water 1,Domestic Hot Water 1; WFU: 2; CWFU: 3; HWFU: 3
Plumbing - Flow Pressure: 16812.2
Dimensions - Shower Width: 915 mm; Cold Water Diameter: 0.0492126; Hot Water Radius: 0.0246063; Shower Length: 915 mm; Cold Water Radius: 0.0246063; Handle Height: 838 mm; Door Width: 572 mm; Sanitary Diameter: 0.082021; Hot Water Diameter: 0.0492126; Sanitary Radius: 0.0410105; Shower Height: 1800 mm
Identity Data - OmniClass Title: Bath/Shower Units; Manufacturer: N/A; Type Mark: P5040; OmniClass Number: 23.45.05.14.21.11
Text - WorkingPressure: 0; OutletConnectionSize: 0; FlowCoefficient: 0; Finish: Chrome
Name (M_Shower Stall - Rectangular:915 mmx915 mm - Public:915 mmx915 mm - Public:...) | In | Host | Level | Mark
620358 | Level 1 | Level : Level 1 | Level: Level 1 | 55
652844 | Level 2 | Level : Level 2 | Level: Level 2 | 105
652945 | Level 2 | Level : Level 2 | Level: Level 2 | 106

# IfcFlowTerminal: Public - 6.1 Lpf (24)
Type - ElementType: Public - 6.1 Lpf; PredefinedType: WCSEAT; Classification:  (UniFormat)
Phasing - Phase Created: New Construction
Other - SerialNumber: N/A; TagNumber: N/A; WarrantyStartDate: N/A; BarCode: N/A; InstallationDate: N/A; AssetIdentifier: N/A; ModelReference: N/A; Constituents: N/A; ModelLabel: N/A; NominalHeight: 0; Features: N/A; HasGrabHandles: TRUE; NominalWidth: 420; PanMounting: PEDESTAL; WarrantyDescription: N/A; CodePerformance: N/A; WarrantyGuarantorLabor: N/A; Finish: Chrome; Reference: Type A - 1; ReplacementCost: N/A; ToiletPanType: SIPHONIC; WarrantyGuarantorParts: N/A; ProductionYear: N/A; BodyMaterial: Brass; SpilloverLevel: 120; ToiletType: CLOSECOUPLED; AssetAccountingType: FIXED; ShowerHeadDescription: Fixed; CloseRating: 0; SustainabilityPerformance: N/A; AccessibilityPerformance: N/A; Size: 0; WarrantyDurationLabor: N/A; Material: N/A; FaucetTopDescription: Cartridge; Grade: N/A; MeasuredPressureDrop: 0; PercentageOpen: 0; Color: White Alpin; WarrantyDurationParts: N/A; MeasuredFlowRate: 0; ExpectedLife: N/A; Shape: N/A; HasTray: TRUE; NominalLength: 710; TestPressure: 0; NominalDepth: 380; DrainSize: 0; MountingOffset: 0
Mechanical - System Name: Domestic Cold Water 1,Sanitary 1; System Classification: Domestic Cold Water,Sanitary; HWFU: 0; WFU: 4; CWFU: 10
Plumbing - Flow Pressure: 52538.1
Constraints - Elevation: 430 mm; Default Elevation: 430 mm
Dimensions - Cold Water Diameter: 0.082021; Sanitary Diameter: 0.328084; Sanitary Radius: 0.164042; Cold Water Radius: 0.0410105
Text - Finish: Chrome; OutletConnectionSize: 0; FlowCoefficient: 0; WorkingPressure: 0
Identity Data - Type Mark: P9050; OmniClass Title: Water Operated Water Closets; OmniClass Number: 23.45.05.21.11.11; Manufacturer: N/A
Name (M_Water Closet - Flush Valve - Wall Mounted:Public - 6.1 Lpf:Public - 6.1 Lpf:...) | In | Mark | Schedule Level | Host
608513 | Level 1 | 14 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt
608521 | Level 1 | 15 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt
609225 | Level 1 | 18 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt
612622 | Level 1 | 27 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt
613410 | Level 1 | 30 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt
613870 | Level 1 | 33 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt
617689 | Level 1 | 47 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt
617710 | Level 1 | 48 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt
620304 | Level 1 | 54 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt
620590 | Level 1 | 56 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt
620629 | Level 1 | 57 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt
620695 | Level 1 | 58 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt
622190 | Level 1 | 64 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt
649166 | Level 2 | 71 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt
649349 | Level 2 | 74 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt
652032 | Level 2 | 96 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt
652072 | Level 2 | 97 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt
652111 | Level 2 | 98 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt
652572 | Level 2 | 102 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt
652596 | Level 2 | 103 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt
653204 | Level 2 | 107 | Level: Level 2 | Grid : 2
653252 | Level 2 | 108 | Level: Level 2 | Linked Revit Model : Clinic_A.rvt
681203 | Level 1 | 118 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt
683476 | Level 1 | 121 | Level: Level 1 | Linked Revit Model : Clinic_A.rvt

# IfcFlowTerminal: Standard (4)
Type - ElementType: Standard; PredefinedType: SANITARYFOUNTAIN; Classification:  (UniFormat)
Constraints - Default Elevation: 915 mm; Host: Linked Revit Model : Clinic_A.rvt
Dimensions - Cold Water Radius: 0.0164042; Sanitary Radius: 0.0524934; Fountain Width: 300 mm; Fountain Length: 300 mm; Sanitary Diameter: 0.104987; Cold Water Diameter: 0.0328084
Mechanical - WFU: 0.5; CWFU: 0.25; HWFU: 0; System Classification: Domestic Cold Water,Sanitary; System Name: Domestic Cold Water 1,Sanitary 1
Text - Finish: Chrome; OutletConnectionSize: 0; WorkingPressure: 0; FlowCoefficient: 0
Identity Data - OmniClass Number: 23.65.70.14.11; Type Mark: R2201; Manufacturer: N/A; OmniClass Title: Drinking Fountains/Coolers
Other - Material: N/A; ShowerHeadDescription: Fixed; Grade: N/A; Size: 0; SustainabilityPerformance: N/A; ReplacementCost: N/A; Constituents: N/A; ModelReference: N/A; HasGrabHandles: TRUE; SpilloverLevel: 0; WarrantyGuarantorLabor: N/A; ModelLabel: N/A; Width 1: 165 mm; WarrantyDescription: N/A; Half Fountain Width: 150 mm; ExpectedLife: N/A; WarrantyGuarantorParts: N/A; AccessibilityPerformance: N/A; CodePerformance: N/A; MountingOffset: 0; NominalDepth: 1; NominalWidth: 0; Finish: Chrome; HasTray: TRUE; MeasuredFlowRate: 0; NominalLength: 0; WarrantyDurationLabor: N/A; Shape: N/A; Color: White; AssetAccountingType: FIXED; Features: N/A; Thickness: 150 mm; TestPressure: 0; DrainSize: 0; CloseRating: 0; PercentageOpen: 0; NominalHeight: 0; Reference: Type A - 1; FaucetTopDescription: Cartridge; WarrantyDurationParts: N/A; BodyMaterial: Brass; MeasuredPressureDrop: 0; ProductionYear: N/A; SerialNumber: N/A; InstallationDate: N/A; TagNumber: N/A; AssetIdentifier: N/A; BarCode: N/A; WarrantyStartDate: N/A
Phasing - Phase Created: New Construction
Plumbing - Flow Pressure: 16812.2
Name (M_Drinking Fountain - Rectangular - Wall Mounted:Standard:Standard:...) | In | Mark | Elevation (mm)
1085411 | Level 2 | 165 | 1000 | Other - Schedule Level: Level: Level 2
1085990 | Level 2 | 166 | 0
1086140 | Level 1 | 167 | 1000 | Other - Schedule Level: Level: Level 1
1086365 | Level 1 | 169 | 0
