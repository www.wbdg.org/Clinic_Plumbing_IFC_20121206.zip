Properties of the parts of a building model (IFC2X3), part 11 of 29

# IfcFlowFitting: Tee - Generic (541)
Name (M_Tee - Generic:Tee - Generic:Tee - Generic:...) | In | Center to End Label | Angle 1 (deg) | Fitting Outside Radius = Insulation Radius | Angle (deg) | Center to End | Fitting Outside Diameter | Size = Overall Size | Nominal Diameter | Tick Size | Nominal Radius | System Type | System Classification | Loss Method | System Name | Mark | Level | Offset (mm) | Host
710823 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8654 | Level: Level 1 | -300 | Level : Level 1
710964 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8665 | Level: Level 1 | -300 | Level : Level 1
711131 | TOF Footing | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8704 | Level: Level 1 | -300 | Level : Level 1
711180 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8718 | Level: Level 1 | -300 | Level : Level 1
711259 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8730 | Level: Level 1 | -300 | Level : Level 1
711571 | TOF Footing | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8759 | Level: Level 1 | -300 | Level : Level 1
712208 | Level 2 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8839 | Level: Level 2 | 300 | Level : Level 2
712684 | Level 1 | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8865 | Level: Level 2 | -1400 | Level : Level 2
712758 | Level 1 | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8871 | Level: Level 2 | -1400 | Level : Level 2
712960 | Level 1 | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8885 | Level: Level 2 | -1430 | Level : Level 2
713039 | Level 1 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8899 | Level: Level 2 | -1430 | Level : Level 2
713188 | Level 1 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8910 | Level: Level 2 | -1430 | Level : Level 2
713324 | Level 1 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8928 | Level: Level 2 | -1500 | Level : Level 2
713699 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 8974 | Level: Level 2 | -1350 | Level : Level 2
713914 | Level 1 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9006 | Level: Level 2 | -1400 | Level : Level 2
714003 | Level 1 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9026 | Level: Level 2 | -1400 | Level : Level 2
714299 | Level 1 | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9036 | Level: Level 2 | -1400 | Level : Level 2
714449 | Level 1 | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9048 | Level: Level 2 | -1400 | Level : Level 2
714475 | Level 1 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9052 | Level: Level 2 | -1400 | Level : Level 2
714846 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9087 | Level: Level 2 | -1400 | Level : Level 2
715266 | Level 1 | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9116 | Level: Level 2 | -1400 | Level : Level 2
715525 | Level 1 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9141 | Level: Level 2 | -1400 | Level : Level 2
715549 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9145 | Level: Level 2 | -1350 | Level : Level 2
715823 | Level 1 | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9182 | Level: Level 2 | -1400 | Level : Level 2
716000 | Level 1 | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9197 | Level: Level 2 | -1400 | Level : Level 2
716277 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9222 | Level: Level 2 | -1400 | Level : Level 2
716381 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9235 | Level: Level 2 | -1400 | Level : Level 2
716628 | Level 1 | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9258 | Level: Level 2 | -1400 | Level : Level 2
716754 | Level 1 | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9265 | Level: Level 2 | -1400 | Level : Level 2
717254 | Level 1 | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9324 | Level: Level 2 | -1400 | Level : Level 2
717381 | Level 1 | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9338 | Level: Level 2 | -1400 | Level : Level 2
717588 | Level 1 | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9355 | Level: Level 2 | -1400 | Level : Level 2
717723 | Level 1 | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9369 | Level: Level 2 | -1400 | Level : Level 2
717868 | Level 1 | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9390 | Level: Level 2 | -1400 | Level : Level 2
718438 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9407 | Level: Level 2 | -1400 | Level : Level 2
718539 | Level 1 | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9416 | Level: Level 2 | -1400 | Level : Level 2
718668 | Level 1 | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9433 | Level: Level 2 | -1400 | Level : Level 2
718877 | Level 1 | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9453 | Level: Level 2 | -1400 | Level : Level 2
718999 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9469 | Level: Level 2 | -1400 | Level : Level 2
719386 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9509 | Level: Level 2 | -1450 | Level : Level 2
719402 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9513 | Level: Level 2 | -1450 | Level : Level 2
719657 | Level 1 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 9531 | Level: Level 2 | -1400 | Level : Level 2
997914 | Level 1 | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.0375 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 9999 | Level: Level 2 | -1688.2 | Level : Level 2
997990 | Level 2 | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0375 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 10009 | Level: Level 2 | 200 | Level : Level 2
1056712 | Level 1 | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 13428 | Level: Level 2 | -1500 | Level : Level 2
1061790 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 13462 | Level: Level 2 | -1688.2 | Level : Level 2
1070305 | Level 2 | 0.296875 | 90 | 0.255208 | 90 | 0.296875 | 0.510417 | 150 mmø-150 mmø-150 mmø | 0.492126 | 0.204167 | 0.246063 | Piping System: Hydronic Supply 1 | Hydronic Supply | 1 | Hydronic Supply 1 | 13714 | Level: Level 2 | 3800 | Level : Level 2
1070332 | Level 2 | 0.296875 | 90 | 0.255208 | 90 | 0.296875 | 0.510417 | 150 mmø-150 mmø-150 mmø | 0.492126 | 0.204167 | 0.246063 | Piping System: Hydronic Return 1 | Hydronic Return | 1 | Hydronic Return 1 | 13724 | Level: Level 2 | 4000 | Level : Level 2
1076257 | Level 1 | 0.0677083 | 90 | 0.0260417 | 90 | 0.0677083 | 0.0520833 | 15 mmø-15 mmø-15 mmø | 0.0492126 | 0.0208333 | 0.0246063 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 13870 | Level: Level 1 | 771.263 | Level : Level 1
1077561 | Level 1 | 0.0885417 | 90 | 0.046875 | 90 | 0.0885417 | 0.09375 | 25 mmø-25 mmø-25 mmø | 0.082021 | 0.0375 | 0.0410105 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 13961 | Level: Level 1 | 200 | Level : Level 1
1079115 | Level 1 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 14075 | Level: Level 1 | 543.338 | Level : Level 1
1079221 | Level 1 | 0.0677083 | 90 | 0.0260417 | 90 | 0.0677083 | 0.0520833 | 15 mmø-15 mmø-15 mmø | 0.0492126 | 0.0208333 | 0.0246063 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 14101 | Level: Level 1 | 300 | Level : Level 1
1080187 | TOF Footing | 0.321008 | 44.1573 | 0.130208 | 44.1573 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 14166 | Level: Level 1 | -500 | Level : Level 1
1080342 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 14179 | Level: Level 1 | -500 | Level : Level 1
1080914 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 14242 | Level: Level 1 | 200 | Level : Level 1
1081007 | TOF Footing | 0.0677083 | 90 | 0.0260417 | 90 | 0.0677083 | 0.0520833 | 15 mmø-15 mmø-15 mmø | 0.0492126 | 0.0208333 | 0.0246063 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 14248 | Level: Level 1 | -350 | Level : Level 1
1081554 | Level 1 | 0.0677083 | 90 | 0.0260417 | 90 | 0.0677083 | 0.0520833 | 15 mmø-15 mmø-15 mmø | 0.0492126 | 0.0208333 | 0.0246063 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 14298 | Level: Level 2 | -1400 | Level : Level 2
1083161 | Level 1 | 0.0677083 | 90 | 0.0260417 | 90 | 0.0677083 | 0.0520833 | 15 mmø-15 mmø-15 mmø | 0.0492126 | 0.0208333 | 0.0246063 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 14428 | Level: Level 2 | -1450 | Level : Level 2
1083582 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 14467 | Level: Level 1 | 2881.8 | Level : Level 1
1083658 | Level 1 | 0.414943 | 45 | 0.171875 | 135 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 14480 | Level: Level 2 | -1688.2 | Level : Level 2
1083745 | Level 1 | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 14496 | Level: Level 2 | -1688.2 | Level : Level 2
1084255 | Level 2 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 14535 | Level: Level 2 | 200 | Level : Level 2
1084470 | Level 1 | 0.151042 | 90 | 0.109375 | 90 | 0.151042 | 0.21875 | 65 mmø-65 mmø-65 mmø | 0.213255 | 0.0875 | 0.106627 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 14557 | Level: Level 2 | -1500 | Level : Level 2
1084990 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 14595 | Level: Level 2 | -1400 | Level : Level 2
1085124 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 14614 | Level: Level 2 | -1400 | Level : Level 2
1085684 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 14632 | Level: Level 2 | -1688.2 | Level : Level 2
1086088 | Level 2 | 0.0677083 | 90 | 0.0260417 | 90 | 0.0677083 | 0.0520833 | 15 mmø-15 mmø-15 mmø | 0.0492126 | 0.0208333 | 0.0246063 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 14678 | Level: Level 2 | 500 | Level : Level 2
1086487 | Level 1 | 0.0677083 | 90 | 0.0260417 | 90 | 0.0677083 | 0.0520833 | 15 mmø-15 mmø-15 mmø | 0.0492126 | 0.0208333 | 0.0246063 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 14703 | Level: Level 1 | 908.719 | Level : Level 1
1086766 | TOF Footing | 0.32325 | 56 | 0.171875 | 56 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 14730 | Level: Level 1 | -500 | Level : Level 1
1086781 | Level 1 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 14736 | Level: Level 1 | 873 | Level : Level 1
1096352 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 14858 | Level: Level 1 | -500 | Level : Level 1
1098444 | TOF Footing | 0.171875 | 90 | 0.130208 | 90 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 14943 | Level: Level 1 | -501.1 | Level : Level 1
1109893 | Level 2 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 15020 | Level: Level 2 | 200 | Level : Level 2
1117828 | Level 2 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 15102 | Level: Level 2 | 200 | Level : Level 2
1118143 | Level 1 | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 15146 | Level: Level 2 | -1400 | Level : Level 2
1118174 | Level 1 | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 15155 | Level: Level 2 | -1400 | Level : Level 2
1124456 | Level 1 | 0.0677083 | 90 | 0.0260417 | 90 | 0.0677083 | 0.0520833 | 15 mmø-15 mmø-15 mmø | 0.0492126 | 0.0208333 | 0.0246063 | Piping System: Domestic Cold Water 1 | Domestic Cold Water | 1 | Domestic Cold Water 1 | 15300 | Level: Level 2 | -1500 | Level : Level 2
1124660 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 15305 | Level: Level 2 | -1400 | Level : Level 2
1124776 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 15317 | Level: Level 2 | -1350 | Level : Level 2
1125252 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 15371 | Level: Level 2 | -1350 | Level : Level 2
1127396 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 15544 | Level: Level 2 | -1688.2 | Level : Level 2
1203510 | Level 1 | 0.078125 | 90 | 0.0364583 | 90 | 0.078125 | 0.0729167 | 20 mmø-20 mmø-20 mmø | 0.0656168 | 0.0291667 | 0.0328084 | Piping System: Domestic Hot Water 1 | Domestic Cold Water | 1 | Domestic Hot Water 1 | 16432 | Level: Level 2 | -1400 | Level : Level 2
1207106 | TOF Footing | 0.41494 | 45.0003 | 0.171875 | 45.0003 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 16486 | Level: Level 1 | -501.123 | Level : Level 1

# IfcFlowFitting: Transition - Generic (1079)
Type - ElementType: Transition - Generic; Classification:  (UniFormat)
Other - JunctionRightRadius: 0; BendRadius: 0; JunctionLeftRadius: 0; TagNumber: N/A; InstallationDate: N/A; WarrantyStartDate: N/A; BarCode: N/A; AssetIdentifier: N/A; JunctionLeftAngle: 0; JunctionRightAngle: 0; SerialNumber: N/A; FlowrateLeakage: 0; LossCoefficient: 0; Shape: N/A; WarrantyGuarantorParts: N/A; NominalWidth: 0; SustainabilityPerformance: N/A; Constituents: N/A; AssetAccountingType: FIXED; FittingLossFactor: 0; BendAngle: 0; Color: White; NominalHeight: 0; Grade: N/A; WarrantyDescription: N/A; ModelLabel: N/A; NominalLength: 0; Features: N/A; CodePerformance: N/A; Material: Material; Lookup Table Name: M_Pipe Fitting - Generic.csv; WarrantyGuarantorLabor: N/A; ReplacementCost: N/A; AccessibilityPerformance: N/A; WarrantyDurationParts: N/A; Reference: Type A - 1; ModelReference: N/A; ProductionYear: N/A; Size: Size; PressureClass: 0; ExpectedLife: N/A; WarrantyDurationLabor: N/A
Mechanical - K Coefficient Table: Reducer/Coupling/Union/Increaser; Insulation Thickness: 0
Phasing - Phase Created: New Construction
Graphics - Use Annotation Scale: yes
Identity Data - OmniClass Title: Pipework Fittings; OmniClass Number: 23.60.30.11.14; Manufacturer: N/A
Text - TemperatureRange: 0; InteriorRoughnessCoefficient: 0; PressureRange: 0
Name (M_Transition - Generic:Transition - Generic:Transition - Generic:...) | In | Fitting Outside Radius 1 = Insulation Radius 1 | Width Offset | Visibility 3 | Visibility 1 | Max Fitting Outside Diameter 12 | Visibility 2 | Fitting Outside Radius 2 = Insulation Radius 2 | Height Offset | System Name | System Classification | System Type | Loss Method | Offset (mm) | Level | Host | Mark | Fitting Outside Diameter 2 | OffsetHeight | Length | Nominal Radius 1 | OffsetWidth | Nominal Radius 2 | Tick Size 2 | Tick Size 1 | Fitting Outside Diameter 1 | Size = Overall Size | Nominal Diameter 1 | Nominal Diameter 2
577816 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 99 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
625373 | TOF Footing | 0.0572917 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 375 | 0.177083 | 0.0524934 | 0.0442708 | 0.0524934 | 0.0524934 | 0.082021 | 0.0708333 | 0.0458333 | 0.114583 | 50 mmø-32 mmø | 0.104987 | 0.164042
630572 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -501.123 | Level: Level 1 | Level : Level 1 | 1004 | 0.09375 | 0.0524934 | 0.0442708 | 0.0524934 | 0.104987 | 0.082021 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.104987 | 0.082021
631202 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -200 | Level: Level 1 | Level : Level 1 | 1083 | 0.09375 | 0.0524934 | 0.0442708 | 0.0524934 | 0.0524934 | 0.082021 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.104987 | 0.082021
631339 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1108 | 0.09375 | 0.0524934 | 0.0442708 | 0.0524934 | 0.0524934 | 0.082021 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.104987 | 0.082021
632132 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.046875 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -334.131 | Level: Level 1 | Level : Level 1 | 1212 | 0.09375 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0375 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.082021
632945 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1277 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
632946 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1278 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
633047 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -241.263 | Level: Level 1 | Level : Level 1 | 1379 | 0.114583 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0524934 | 0.0458333 | 0.1375 | 0.34375 | 100 mmø-32 mmø | 0.328084 | 0.104987
633050 | TOF Footing | 0.171875 | 10.0279 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1382 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.191988 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
633051 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -441.263 | Level: Level 1 | Level : Level 1 | 1383 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
633211 | TOF Footing | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1402 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
633298 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1414 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
633460 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1430 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
633602 | TOF Footing | 0.0572917 | 10 | yes | no | 0.34375 | no | 0.171875 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1444 | 0.34375 | 0.0524934 | 0.0859375 | 0.0524934 | 0.0524934 | 0.164042 | 0.1375 | 0.0458333 | 0.114583 | 100 mmø-32 mmø | 0.104987 | 0.328084
633841 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1475 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
633883 | Level 1 | 0.0572917 | 10 | yes | no | 0.34375 | no | 0.171875 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | 76.1875 | Level: Level 1 | Level : Level 1 | 1483 | 0.34375 | 0.0525167 | 0.0859375 | 0.0524934 | 0.0524946 | 0.164042 | 0.1375 | 0.0458333 | 0.114583 | 100 mmø-32 mmø | 0.104987 | 0.328084
634099 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | 2900 | Level: Level 1 | Level : Level 1 | 1507 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
634213 | Level 1 | 0.0572917 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | 2876.19 | Level: Level 1 | Level : Level 1 | 1524 | 0.177083 | 0.0524934 | 0.0442708 | 0.0524934 | 0.0524934 | 0.082021 | 0.0708333 | 0.0458333 | 0.114583 | 50 mmø-32 mmø | 0.104987 | 0.164042
634236 | Level 1 | 0.0572917 | 10.0018 | no | yes | 0.114583 | no | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | 231.963 | Level: Level 1 | Level : Level 1 | 1530 | 0.114583 | 0.0524934 | 0.0286458 | 0.0524934 | 0.0543347 | 0.0524934 | 0.0458333 | 0.0458333 | 0.114583 | 32 mmø-32 mmø | 0.104987 | 0.104987
634242 | Level 1 | 0.0885417 | 10.0059 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | 231.963 | Level: Level 1 | Level : Level 1 | 1534 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.0879078 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
634295 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1549 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
634373 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | 232.932 | Level: Level 1 | Level : Level 1 | 1557 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
634378 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -434.912 | Level: Level 1 | Level : Level 1 | 1561 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
634429 | Level 1 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | 0 | Level: Level 1 | Level : Level 1 | 1572 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
634493 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1592 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
634528 | TOF Footing | 0.0572917 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1599 | 0.177083 | 0.0524934 | 0.0442708 | 0.0524934 | 0.0524934 | 0.082021 | 0.0708333 | 0.0458333 | 0.114583 | 50 mmø-32 mmø | 0.104987 | 0.164042
634601 | Level 1 | 0.0572917 | 10 | yes | no | 0.34375 | no | 0.171875 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | 0 | Level: Level 1 | Level : Level 1 | 1613 | 0.34375 | 0.0524934 | 0.0859375 | 0.0524934 | 0.0524934 | 0.164042 | 0.1375 | 0.0458333 | 0.114583 | 100 mmø-32 mmø | 0.104987 | 0.328084
634783 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1640 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
634796 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -300 | Level: Level 1 | Level : Level 1 | 1646 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
634827 | TOF Footing | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1660 | 0.135417 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.0656168 | 0.0541667 | 0.104167 | 0.260417 | 80 mmø-40 mmø | 0.262467 | 0.131234
634837 | TOF Footing | 0.0572917 | 10 | yes | no | 0.135417 | no | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1664 | 0.135417 | 0.0524934 | 0.0338542 | 0.0524934 | 0.0524934 | 0.0656168 | 0.0541667 | 0.0458333 | 0.114583 | 40 mmø-32 mmø | 0.104987 | 0.131234
635009 | TOF Footing | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -447.612 | Level: Level 1 | Level : Level 1 | 1677 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
635044 | TOF Footing | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1687 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
635121 | TOF Footing | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1710 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
635154 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -340.489 | Level: Level 1 | Level : Level 1 | 1718 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
635285 | TOF Footing | 0.0677083 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -326.987 | Level: Level 1 | Level : Level 1 | 1742 | 0.177083 | 0.0656168 | 0.0442708 | 0.0656168 | 0.0656168 | 0.082021 | 0.0708333 | 0.0541667 | 0.135417 | 50 mmø-40 mmø | 0.131234 | 0.164042
635376 | TOF Footing | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1768 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
635395 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1775 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
635651 | TOF Footing | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -447.613 | Level: Level 1 | Level : Level 1 | 1781 | 0.135417 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.0656168 | 0.0541667 | 0.104167 | 0.260417 | 80 mmø-40 mmø | 0.262467 | 0.131234
635703 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1794 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
635823 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1808 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
635857 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -460.312 | Level: Level 1 | Level : Level 1 | 1814 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
636100 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1857 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
636344 | TOF Footing | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1876 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
636423 | TOF Footing | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1884 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
636441 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1889 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
636561 | TOF Footing | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1906 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
636670 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1921 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
636682 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1930 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
636776 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1941 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
636886 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 1958 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
637264 | TOF Footing | 0.046875 | 9.99924 | yes | no | 0.34375 | no | 0.171875 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -501.123 | Level: Level 1 | Level : Level 1 | 1997 | 0.34375 | 0.0410105 | 0.0859375 | 0.0410105 | 0.0402463 | 0.164042 | 0.1375 | 0.0375 | 0.09375 | 100 mmø-25 mmø | 0.082021 | 0.328084
637398 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -501.123 | Level: Level 1 | Level : Level 1 | 2006 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
637432 | Level 1 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | 300 | Level: Level 1 | Level : Level 1 | 2017 | 0.114583 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.0524934 | 0.0458333 | 0.104167 | 0.260417 | 80 mmø-32 mmø | 0.262467 | 0.104987
637530 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -501.123 | Level: Level 1 | Level : Level 1 | 2038 | 0.114583 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0524934 | 0.0458333 | 0.1375 | 0.34375 | 100 mmø-32 mmø | 0.328084 | 0.104987
637632 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -501.123 | Level: Level 1 | Level : Level 1 | 2054 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
637643 | TOF Footing | 0.0572917 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -501.123 | Level: Level 1 | Level : Level 1 | 2058 | 0.177083 | 0.0524934 | 0.0442708 | 0.0524934 | 0.0524934 | 0.082021 | 0.0708333 | 0.0458333 | 0.114583 | 50 mmø-32 mmø | 0.104987 | 0.164042
637712 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -501.123 | Level: Level 1 | Level : Level 1 | 2074 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
637745 | Level 1 | 0.0572917 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | 526.188 | Level: Level 1 | Level : Level 1 | 2078 | 0.177083 | 0.0524934 | 0.0442708 | 0.0524934 | 0.0524934 | 0.082021 | 0.0708333 | 0.0458333 | 0.114583 | 50 mmø-32 mmø | 0.104987 | 0.164042
638174 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -501.123 | Level: Level 1 | Level : Level 1 | 2120 | 0.114583 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0524934 | 0.0458333 | 0.1375 | 0.34375 | 100 mmø-32 mmø | 0.328084 | 0.104987
638353 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -501.123 | Level: Level 1 | Level : Level 1 | 2127 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
639163 | TOF Footing | 0.0885417 | 10 | yes | no | 0.260417 | no | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -467.786 | Level: Level 1 | Level : Level 1 | 2169 | 0.260417 | 0.082021 | 0.0651042 | 0.082021 | 0.082021 | 0.131234 | 0.104167 | 0.0708333 | 0.177083 | 80 mmø-50 mmø | 0.164042 | 0.262467
639188 | Level 1 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | 400 | Level: Level 1 | Level : Level 1 | 2179 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
639221 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -501.123 | Level: Level 1 | Level : Level 1 | 2185 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
639370 | TOF Footing | 0.0572917 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -501.123 | Level: Level 1 | Level : Level 1 | 2205 | 0.177083 | 0.0524934 | 0.0442708 | 0.0524934 | 0.0524934 | 0.082021 | 0.0708333 | 0.0458333 | 0.114583 | 50 mmø-32 mmø | 0.104987 | 0.164042
639410 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -501.123 | Level: Level 1 | Level : Level 1 | 2210 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
639474 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -501.123 | Level: Level 1 | Level : Level 1 | 2228 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
639651 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -501.123 | Level: Level 1 | Level : Level 1 | 2246 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
639662 | TOF Footing | 0.0572917 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -501.123 | Level: Level 1 | Level : Level 1 | 2251 | 0.177083 | 0.0524934 | 0.0442708 | 0.0524934 | 0.0524934 | 0.082021 | 0.0708333 | 0.0458333 | 0.114583 | 50 mmø-32 mmø | 0.104987 | 0.164042
639864 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -501.123 | Level: Level 1 | Level : Level 1 | 2287 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
639944 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | 0 | Level: Level 1 | Level : Level 1 | 2305 | 0.114583 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0524934 | 0.0458333 | 0.1375 | 0.34375 | 100 mmø-32 mmø | 0.328084 | 0.104987
639952 | TOF Footing | 0.0572917 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 2307 | 0.177083 | 0.0524934 | 0.0442708 | 0.0524934 | 0.0524934 | 0.082021 | 0.0708333 | 0.0458333 | 0.114583 | 50 mmø-32 mmø | 0.104987 | 0.164042
640024 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 2319 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
640087 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 2329 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
640112 | TOF Footing | 0.0572917 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 2336 | 0.177083 | 0.0524934 | 0.0442708 | 0.0524934 | 0.0524934 | 0.082021 | 0.0708333 | 0.0458333 | 0.114583 | 50 mmø-32 mmø | 0.104987 | 0.164042
640200 | TOF Footing | 0.0885417 | 10 | yes | no | 0.34375 | no | 0.171875 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 2342 | 0.34375 | 0.082021 | 0.0859375 | 0.082021 | 0.082021 | 0.164042 | 0.1375 | 0.0708333 | 0.177083 | 100 mmø-50 mmø | 0.164042 | 0.328084
640550 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.130208 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 2385 | 0.260417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.131234 | 0.104167 | 0.1375 | 0.34375 | 100 mmø-80 mmø | 0.328084 | 0.262467
640565 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 2389 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
640630 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 2405 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
641155 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -460.312 | Level: Level 1 | Level : Level 1 | 2420 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
641195 | TOF Footing | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 2427 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
641197 | TOF Footing | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 2428 | 0.114583 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0524934 | 0.0458333 | 0.0541667 | 0.135417 | 40 mmø-32 mmø | 0.131234 | 0.104987
641239 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -460.312 | Level: Level 1 | Level : Level 1 | 2438 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
641265 | TOF Footing | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -447.612 | Level: Level 1 | Level : Level 1 | 2450 | 0.135417 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.0656168 | 0.0541667 | 0.104167 | 0.260417 | 80 mmø-40 mmø | 0.262467 | 0.131234
641366 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -5030.31 | Level: Level 2 | Level : Level 2 | 2461 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
641385 | TOF Footing | 0.0572917 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 2466 | 0.177083 | 0.0524934 | 0.0442708 | 0.0524934 | 0.0524934 | 0.082021 | 0.0708333 | 0.0458333 | 0.114583 | 50 mmø-32 mmø | 0.104987 | 0.164042
641513 | TOF Footing | 0.0885417 | 10 | yes | no | 0.34375 | no | 0.171875 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -5070 | Level: Level 2 | Level : Level 2 | 2471 | 0.34375 | 0.082021 | 0.0859375 | 0.082021 | 0.082021 | 0.164042 | 0.1375 | 0.0708333 | 0.177083 | 100 mmø-50 mmø | 0.164042 | 0.328084
641603 | TOF Footing | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 2478 | 0.177083 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.082021 | 0.0708333 | 0.104167 | 0.260417 | 80 mmø-50 mmø | 0.262467 | 0.164042
641639 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -460.312 | Level: Level 1 | Level : Level 1 | 2489 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
641981 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -460.312 | Level: Level 1 | Level : Level 1 | 2525 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
642089 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -434.912 | Level: Level 1 | Level : Level 1 | 2554 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
642174 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 2564 | 0.114583 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0524934 | 0.0458333 | 0.1375 | 0.34375 | 100 mmø-32 mmø | 0.328084 | 0.104987
642807 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | 65.0875 | Level: Level 1 | Level : Level 1 | 2654 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
643067 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 2672 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
643197 | TOF Footing | 0.0572917 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 2695 | 0.177083 | 0.0524934 | 0.0442708 | 0.0524934 | 0.0524934 | 0.082021 | 0.0708333 | 0.0458333 | 0.114583 | 50 mmø-32 mmø | 0.104987 | 0.164042
643375 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -460.312 | Level: Level 1 | Level : Level 1 | 2719 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
643591 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -460.312 | Level: Level 1 | Level : Level 1 | 2744 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
643622 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -460.312 | Level: Level 1 | Level : Level 1 | 2753 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
644020 | TOF Footing | 0.0572917 | 10 | yes | no | 0.177083 | no | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 2787 | 0.177083 | 0.0524934 | 0.0442708 | 0.0524934 | 0.0524934 | 0.082021 | 0.0708333 | 0.0458333 | 0.114583 | 50 mmø-32 mmø | 0.104987 | 0.164042
644025 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -500 | Level: Level 1 | Level : Level 1 | 2791 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
644187 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -460.312 | Level: Level 1 | Level : Level 1 | 2817 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
644194 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -300 | Level: Level 1 | Level : Level 1 | 2823 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
644347 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -501.123 | Level: Level 1 | Level : Level 1 | 2826 | 0.135417 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.0656168 | 0.0541667 | 0.1375 | 0.34375 | 100 mmø-40 mmø | 0.328084 | 0.131234
644741 | Level 1 | 0.171875 | 10 | no | yes | 0.34375 | no | 0.171875 | 10.0024 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | 232.205 | Level: Level 1 | Level : Level 1 | 2846 | 0.34375 | 0.166428 | 0.0859375 | 0.164042 | 0.164041 | 0.164042 | 0.1375 | 0.1375 | 0.34375 | 100 mmø-100 mmø | 0.328084 | 0.328084
644759 | Level 1 | 0.130208 | 10 | no | no | 0.260417 | yes | 0.0677083 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | 352.388 | Level: Level 1 | Level : Level 1 | 2850 | 0.135417 | 0.131234 | 0.0651042 | 0.131234 | 0.131234 | 0.0656168 | 0.0541667 | 0.104167 | 0.260417 | 80 mmø-40 mmø | 0.262467 | 0.131234
644847 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -501.123 | Level: Level 1 | Level : Level 1 | 2861 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
644848 | TOF Footing | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0572917 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -501.123 | Level: Level 1 | Level : Level 1 | 2862 | 0.114583 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0524934 | 0.0458333 | 0.0708333 | 0.177083 | 50 mmø-32 mmø | 0.164042 | 0.104987
644912 | Level 1 | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | 298.02 | Level: Level 1 | Level : Level 1 | 2869 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
645358 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 5 | -436.036 | Level: Level 1 | Level : Level 1 | 2898 | 0.177083 | 0.164042 | 0.0859375 | 0.164042 | 0.164042 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042
