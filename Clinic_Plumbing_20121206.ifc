Properties of the parts of a building model (IFC2X3), part 23 of 29

# IfcFlowSegment: Pipe Types:Hot Water:699832 (871)
Name (Pipe Types:Hot Water:...) | In | System Type | Invert Elevation (mm) | System Name | System Classification | Area (mm2) | Diameter | Section | Offset (mm) = Start Offset (mm) | Slope | End Offset (mm) | Reference Level | Reynolds Number | Flow State | Friction | Relative Roughness | Velocity | Friction Factor | Pressure Drop | Fixture Units | Flow | Inner Diameter | Size = Overall Size | Length (mm) | Outer Diameter | Mark
706772 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 143795 | 0.0492126 | 98 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 3051.43 | 0.0416667 | 2953
706793 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 30227.3 | 0.0492126 | 98 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 641.443 | 0.0416667 | 2954
706802 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 1982.98 | 0.0492126 | 98 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 42.0802 | 0.0416667 | 2955
706865 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 98 | -285.713 |  | 185.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 2956
706869 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 2557.71 | 0.0492126 | 98 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 54.2762 | 0.0416667 | 2957
706875 | Level 1 | Piping System: Domestic Hot Water 1 | 214.287 | Domestic Hot Water 1 | Domestic Hot Water | 27517.3 | 0.0492126 | 98 | 214.287 | 7913.3 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 583.936 | 0.0416667 | 2958
706923 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 23491.1 | 0.0492126 | 100 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 498.497 | 0.0416667 | 2959
706960 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 54633.7 | 0.0492126 | 347 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1159.36 | 0.0416667 | 2960
706967 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 40533.9 | 0.0492126 | 102 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 860.157 | 0.0416667 | 2961
706975 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 52374.7 | 0.0492126 | 102 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1111.43 | 0.0416667 | 2962
707016 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 2631.81 | 0.0492126 | 102 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 55.8487 | 0.0416667 | 2963
707044 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 102 | -285.713 |  | 185.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 2964
707048 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 2736.47 | 0.0492126 | 102 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 58.0698 | 0.0416667 | 2965
707054 | Level 1 | Piping System: Domestic Hot Water 1 | 214.287 | Domestic Hot Water 1 | Domestic Hot Water | 27517.3 | 0.0492126 | 102 | 214.287 | 7913.3 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 583.936 | 0.0416667 | 2966
707127 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 119635 | 0.0492126 | 381 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 2538.73 | 0.0416667 | 2969
707144 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 111421 | 0.0656168 | 420 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1773.32 | 0.0625 | 2970
707151 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 47730.9 | 0.104987 | 413 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 474.788 | 0.104167 | 2971
707186 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 29786.6 | 0.104987 | 398 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 296.293 | 0.104167 | 2972
707202 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 215386 | 0.0492126 | 350 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 4570.63 | 0.0416667 | 2973
707232 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 82354.1 | 0.0492126 | 382 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1747.61 | 0.0416667 | 2974
707238 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 10389.6 | 0.0492126 | 351 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 220.474 | 0.0416667 | 2975
707250 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 119527 | 0.104987 | 366 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 1188.96 | 0.104167 | 2976
707267 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 124928 | 0.082021 | 353 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 1590.63 | 0.0833333 | 2977
707299 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 10085.3 | 0.082021 | 359 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 128.41 | 0.0833333 | 2978
707310 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 58630.5 | 0.0656168 | 358 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 933.133 | 0.0625 | 2979
707325 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 171239 | 0.0492126 | 355 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 3633.81 | 0.0416667 | 2980
707342 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 46434.2 | 0.0492126 | 58 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 985.364 | 0.0416667 | 2981
707347 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 58 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 2982
707364 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 36352.5 | 0.0492126 | 58 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 771.425 | 0.0416667 | 2983
707369 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 4555.98 | 0.0492126 | 58 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 96.681 | 0.0416667 | 2984
707402 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 58 | -285.713 |  | 185.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 2985
707406 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 5737.18 | 0.0492126 | 58 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 121.747 | 0.0416667 | 2986
707412 | Level 1 | Piping System: Domestic Hot Water 1 | 214.289 | Domestic Hot Water 1 | Domestic Hot Water | 27517.2 | 0.0492126 | 58 | 214.29 | 5212.45 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 583.934 | 0.0416667 | 2987
707586 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 6112.63 | 0.0492126 | 356 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 129.714 | 0.0416667 | 2996
707589 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 23313.3 | 0.0492126 | 60 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 494.724 | 0.0416667 | 2997
707605 | Level 1 | Piping System: Domestic Hot Water 1 | -255.33 | Domestic Hot Water 1 | Domestic Hot Water | 378016 | 0.0492126 | 357 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 8021.76 | 0.0416667 | 2998
707687 | Level 1 | Piping System: Domestic Hot Water 1 | -255.33 | Domestic Hot Water 1 | Domestic Hot Water | 422580 | 0.0492126 | 394 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 8967.43 | 0.0416667 | 3000
707725 | Level 1 | Piping System: Domestic Hot Water 1 | -255.33 | Domestic Hot Water 1 | Domestic Hot Water | 38936 | 0.0492126 | 356 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 826.249 | 0.0416667 | 3001
707739 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 14684.2 | 0.0492126 | 48 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 311.609 | 0.0416667 | 3002
707744 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 48512.4 | 0.0656168 | 354 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 772.099 | 0.0625 | 3003
707748 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 4883.27 | 0.0492126 | 48 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 103.626 | 0.0416667 | 3004
707806 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 48 | -285.713 |  | 185.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 3005
707810 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 4182.19 | 0.0492126 | 48 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 88.7487 | 0.0416667 | 3006
707816 | Level 1 | Piping System: Domestic Hot Water 1 | 214.287 | Domestic Hot Water 1 | Domestic Hot Water | 27517.3 | 0.0492126 | 48 | 214.287 |  | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 583.936 | 0.0416667 | 3007
707832 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 14125.2 | 0.0492126 | 50 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 299.747 | 0.0416667 | 3008
707846 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 186503 | 0.082021 | 364 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 2374.63 | 0.0833333 | 3009
707851 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 287218 | 0.082021 | 353 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 3656.98 | 0.0833333 | 3010
707853 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 24733.5 | 0.082021 | 363 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 314.917 | 0.0833333 | 3011
707953 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 41854.3 | 0.0656168 | 31 | -300 | 0 | -300 | Level: Level 1 | 56164 | 2 | 99.4454 | 6381.89 | 5.391 | 0.0130723 | 217.335 | 2.25 | 0.0119756 | 0.0531824 | 20 mmø | 666.131 | 0.0625 | 3012
707960 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 71635.7 | 0.0492126 | 30 | -300 | 0 | -300 | Level: Level 1 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 4390.51 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 1520.16 | 0.0416667 | 3013
708012 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 29544.3 | 0.0492126 | 30 | -285.713 |  | 341.238 | Level: Level 1 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 1810.75 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 626.95 | 0.0416667 | 3015
708021 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 33512.5 | 0.0492126 | 62 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 711.157 | 0.0416667 | 3016
708026 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 59005.4 | 0.0656168 | 361 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 939.1 | 0.0625 | 3017
708030 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 4273.26 | 0.0492126 | 62 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 90.6814 | 0.0416667 | 3018
708062 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 62 | -285.713 |  | 185.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 3019
708066 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 4161 | 0.0492126 | 62 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 88.2992 | 0.0416667 | 3020
708072 | Level 1 | Piping System: Domestic Hot Water 1 | 214.289 | Domestic Hot Water 1 | Domestic Hot Water | 27517.2 | 0.0492126 | 62 | 214.29 | 5212.45 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 583.934 | 0.0416667 | 3021
708081 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 15779.6 | 0.082021 | 364 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 200.912 | 0.0833333 | 3022
708095 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 54932.9 | 0.0656168 | 66 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 874.285 | 0.0625 | 3023
708102 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 391832 | 0.082021 | 360 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 4988.96 | 0.0833333 | 3024
708106 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 60637.5 | 0.0656168 | 66 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 965.075 | 0.0625 | 3025
708111 | Level 1 | Piping System: Domestic Hot Water 1 | 191.895 | Domestic Hot Water 1 | Domestic Hot Water | 5980.1 | 0.0656168 | 66 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 95.1763 | 0.0625 | 3026
708144 | Level 1 | Piping System: Domestic Hot Water 1 | -282.538 | Domestic Hot Water 1 | Domestic Hot Water | 29221.5 | 0.0656168 | 66 | -282.538 |  | 182.538 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 465.075 | 0.0625 | 3027
708148 | Level 1 | Piping System: Domestic Hot Water 1 | 191.895 | Domestic Hot Water 1 | Domestic Hot Water | 5333.41 | 0.0656168 | 66 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 84.8838 | 0.0625 | 3028
708154 | Level 1 | Piping System: Domestic Hot Water 1 | 223.02 | Domestic Hot Water 1 | Domestic Hot Water | 27105.8 | 0.0492126 | 65 | 223.021 | 5213.32 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 575.202 | 0.0416667 | 3029
708298 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 28219.9 | 0.0656168 | 68 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 449.134 | 0.0625 | 3034
708353 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 1009.63 | 0.0492126 | 356 | -285.713 |  | -264.287 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 21.425 | 0.0416667 | 3035
708400 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 144344 | 0.0492126 | 53 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 3063.07 | 0.0416667 | 3036
708407 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 130173 | 0.104987 | 367 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 1294.86 | 0.104167 | 3037
708411 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 72166.7 | 0.0492126 | 53 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1531.43 | 0.0416667 | 3038
708418 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 4095.96 | 0.0492126 | 53 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 86.919 | 0.0416667 | 3039
708470 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 53 | -285.713 |  | 185.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 3040
708474 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 4013.98 | 0.0492126 | 53 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 85.1794 | 0.0416667 | 3041
708486 | Level 1 | Piping System: Domestic Hot Water 1 | 214.287 | Domestic Hot Water 1 | Domestic Hot Water | 27517.3 | 0.0492126 | 53 | 214.287 |  | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 583.936 | 0.0416667 | 3042
708515 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 27744.7 | 0.0492126 | 55 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 588.76 | 0.0416667 | 3043
708529 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 6625.42 | 0.0492126 | 106 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 140.596 | 0.0416667 | 3044
708536 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 32005.1 | 0.104987 | 368 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 318.361 | 0.104167 | 3045
708540 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 64626.9 | 0.0492126 | 106 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1371.43 | 0.0416667 | 3046
708545 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 31002.7 | 0.0492126 | 106 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 657.897 | 0.0416667 | 3047
708552 | Level 1 | Piping System: Domestic Hot Water 1 | 494.67 | Domestic Hot Water 1 | Domestic Hot Water | 2407.83 | 0.0492126 | 106 | 500 | 0 | 500 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 51.0958 | 0.0416667 | 3048
708594 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 36352.5 | 0.0492126 | 106 | -285.713 |  | 485.712 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 771.425 | 0.0416667 | 3049
708598 | Level 1 | Piping System: Domestic Hot Water 1 | 494.67 | Domestic Hot Water 1 | Domestic Hot Water | 4337.69 | 0.0492126 | 106 | 500 | 0 | 500 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 92.0487 | 0.0416667 | 3050
708611 | Level 1 | Piping System: Domestic Hot Water 1 | 514.29 | Domestic Hot Water 1 | Domestic Hot Water | 13380 | 0.0492126 | 106 | 514.292 | 2629.02 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 283.932 | 0.0416667 | 3051
708620 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 18907.8 | 0.0492126 | 108 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 401.235 | 0.0416667 | 3052
708635 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 18424.9 | 0.0492126 | 370 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 390.988 | 0.0416667 | 3053
708654 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 96671.1 | 0.0492126 | 371 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 2051.43 | 0.0416667 | 3056
708659 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 21272.9 | 0.0492126 | 371 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 451.425 | 0.0416667 | 3057
708670 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 9208.52 | 0.0492126 | 371 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 195.411 | 0.0416667 | 3058
708691 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 371 | -285.713 |  | 185.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 3059
708798 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 171056 | 0.104987 | 373 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 1701.53 | 0.104167 | 3063
708871 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 73081.8 | 0.0492126 | 371 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1550.84 | 0.0416667 | 3064
708885 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 19800.2 | 0.0492126 | 43 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 420.173 | 0.0416667 | 3065
708892 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 325389 | 0.104987 | 374 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 3236.7 | 0.104167 | 3066
708896 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 30697.7 | 0.0492126 | 43 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 651.425 | 0.0416667 | 3067
708930 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 3866.99 | 0.0492126 | 43 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 82.0602 | 0.0416667 | 3068
708937 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 43 | -285.713 |  | 185.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 3069
708941 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 2054.07 | 0.0492126 | 43 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 43.5887 | 0.0416667 | 3070
708949 | Level 1 | Piping System: Domestic Hot Water 1 | 214.289 | Domestic Hot Water 1 | Domestic Hot Water | 27517.2 | 0.0492126 | 43 | 214.29 | 5212.45 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 583.934 | 0.0416667 | 3071
708974 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 24582.6 | 0.0492126 | 45 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 521.659 | 0.0416667 | 3072
709012 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 39509.8 | 0.0656168 | 377 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 628.818 | 0.0625 | 3073
709019 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 112649 | 0.104987 | 385 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 1120.54 | 0.104167 | 3074
709023 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 37075.5 | 0.0656168 | 377 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 590.075 | 0.0625 | 3075
709038 | Level 1 | Piping System: Domestic Hot Water 1 | 191.895 | Domestic Hot Water 1 | Domestic Hot Water | 11455.8 | 0.0656168 | 377 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 182.324 | 0.0625 | 3076
709074 | Level 1 | Piping System: Domestic Hot Water 1 | -282.538 | Domestic Hot Water 1 | Domestic Hot Water | 29221.5 | 0.0656168 | 377 | -282.538 |  | 182.538 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 465.075 | 0.0625 | 3077
709078 | Level 1 | Piping System: Domestic Hot Water 1 | 191.895 | Domestic Hot Water 1 | Domestic Hot Water | 1125.37 | 0.0656168 | 377 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 17.9109 | 0.0625 | 3078
709090 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 32592.5 | 0.0656168 | 378 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 518.725 | 0.0625 | 3080
709097 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 195715 | 0.0656168 | 380 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 3114.91 | 0.0625 | 3081
709098 | Level 1 | Piping System: Domestic Hot Water 1 | 191.895 | Domestic Hot Water 1 | Domestic Hot Water | 13649.8 | 0.0656168 | 378 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 217.243 | 0.0625 | 3082
709141 | Level 1 | Piping System: Domestic Hot Water 1 | -282.538 | Domestic Hot Water 1 | Domestic Hot Water | 29221.5 | 0.0656168 | 378 | -282.538 |  | 182.538 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 465.075 | 0.0625 | 3083
709178 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 44441.4 | 0.0656168 | 376 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 707.307 | 0.0625 | 3086
709236 | Level 1 | Piping System: Domestic Hot Water 1 | -255.33 | Domestic Hot Water 1 | Domestic Hot Water | 700148 | 0.0492126 | 394 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 14857.6 | 0.0416667 | 3087
709275 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 1009.63 | 0.0492126 | 394 | -285.713 |  | -264.287 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 21.425 | 0.0416667 | 3089
709296 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 23491.1 | 0.0492126 | 104 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 498.497 | 0.0416667 | 3090
709299 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 10415 | 0.0492126 | 394 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 221.013 | 0.0416667 | 3091
709335 | Level 2 | Piping System: Domestic Hot Water 1 | 3152.58 | Domestic Hot Water 1 | Domestic Hot Water | 54850.6 | 0.131234 | 474 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 436.487 | 0.125 | 3092
709345 | Level 1 | Piping System: Domestic Hot Water 1 | -275.394 | Domestic Hot Water 1 | Domestic Hot Water | 429570 | 0.131234 | 474 | -275.394 |  | 3143.01 | Level: Level 1 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 3418.41 | 0.125 | 3093
709393 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 11927.8 | 0.0492126 | 383 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 253.116 | 0.0416667 | 3094
709446 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 40391.5 | 0.0656168 | 388 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 642.85 | 0.0625 | 3095
709457 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 39745.5 | 0.0656168 | 389 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 632.569 | 0.0625 | 3097
709462 | Level 1 | Piping System: Domestic Hot Water 1 | 191.895 | Domestic Hot Water 1 | Domestic Hot Water | 11694.7 | 0.0656168 | 389 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 186.128 | 0.0625 | 3098
709524 | Level 1 | Piping System: Domestic Hot Water 1 | -282.538 | Domestic Hot Water 1 | Domestic Hot Water | 29221.5 | 0.0656168 | 389 | -282.538 |  | 182.538 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 465.075 | 0.0625 | 3099
709592 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 25543 | 0.104987 | 352 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 254.081 | 0.104167 | 3102
709615 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 197161 | 0.0656168 | 391 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 3137.92 | 0.0625 | 3104
709632 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 36133 | 0.0656168 | 388 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 575.075 | 0.0625 | 3105
709639 | Level 1 | Piping System: Domestic Hot Water 1 | 191.895 | Domestic Hot Water 1 | Domestic Hot Water | 15085.3 | 0.0656168 | 388 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 240.09 | 0.0625 | 3106
709676 | Level 1 | Piping System: Domestic Hot Water 1 | -282.538 | Domestic Hot Water 1 | Domestic Hot Water | 29221.5 | 0.0656168 | 388 | -282.538 |  | 182.538 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 465.075 | 0.0625 | 3107
709695 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 30803.9 | 0.0656168 | 387 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 490.259 | 0.0625 | 3110
709709 | Level 1 | Piping System: Domestic Hot Water 1 | -258.105 | Domestic Hot Water 1 | Domestic Hot Water | 106173 | 0.0656168 | 397 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1689.79 | 0.0625 | 3111
709716 | Level 1 | Piping System: Domestic Hot Water 1 | -255.33 | Domestic Hot Water 1 | Domestic Hot Water | 522421 | 0.0492126 | 357 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 11086.1 | 0.0416667 | 3112
709819 | Level 1 | Piping System: Domestic Hot Water 1 | -258.105 | Domestic Hot Water 1 | Domestic Hot Water | 48857.8 | 0.0656168 | 393 | -250 | 0 | -250 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 777.596 | 0.0625 | 3115
709837 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 37678.5 | 0.0656168 | 401 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 599.671 | 0.0625 | 3116
709844 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 37243.4 | 0.104987 | 406 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 370.467 | 0.104167 | 3117
709848 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 28974.4 | 0.0656168 | 401 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 461.141 | 0.0625 | 3118
709982 | Level 1 | Piping System: Domestic Hot Water 1 | 191.895 | Domestic Hot Water 1 | Domestic Hot Water | 15968 | 0.0656168 | 401 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 254.138 | 0.0625 | 3119
709989 | Level 1 | Piping System: Domestic Hot Water 1 | -282.538 | Domestic Hot Water 1 | Domestic Hot Water | 29221.5 | 0.0656168 | 401 | -282.538 |  | 182.538 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 465.075 | 0.0625 | 3120
710089 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 19377.5 | 0.0492126 | 403 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 411.203 | 0.0416667 | 3123
710094 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 215626 | 0.0656168 | 405 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 3431.79 | 0.0625 | 3124
710098 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 5547.77 | 0.0492126 | 403 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 117.727 | 0.0416667 | 3125
710133 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 403 | -285.713 |  | 185.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 3126
710204 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 41182.9 | 0.0656168 | 400 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 655.447 | 0.0625 | 3129
710234 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 105438 | 0.0492126 | 38 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 2237.47 | 0.0416667 | 3130
710241 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 194060 | 0.104987 | 407 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 1930.35 | 0.104167 | 3131
710245 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 29755.2 | 0.0492126 | 38 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 631.425 | 0.0416667 | 3132
710254 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 3394.13 | 0.0492126 | 38 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 72.0256 | 0.0416667 | 3133
710306 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 38 | -285.713 |  | 185.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 3134
710310 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 1507.8 | 0.0492126 | 38 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 31.9964 | 0.0416667 | 3135
710316 | Level 1 | Piping System: Domestic Hot Water 1 | 214.287 | Domestic Hot Water 1 | Domestic Hot Water | 27517.3 | 0.0492126 | 38 | 214.287 | 7914.47 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 583.936 | 0.0416667 | 3136
710350 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 11515.1 | 0.0492126 | 40 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 244.358 | 0.0416667 | 3137
710377 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 30848.4 | 0.0492126 | 33 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 654.623 | 0.0416667 | 3138
710384 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 154746 | 0.104987 | 408 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 1539.29 | 0.104167 | 3139
710388 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 46012.9 | 0.0492126 | 33 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 976.425 | 0.0416667 | 3140
710393 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 1597.04 | 0.0492126 | 33 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 33.8902 | 0.0416667 | 3141
710448 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 33 | -285.713 |  | 185.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 3142
710452 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 3660.12 | 0.0492126 | 33 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 77.6701 | 0.0416667 | 3143
710458 | Level 1 | Piping System: Domestic Hot Water 1 | 214.287 | Domestic Hot Water 1 | Domestic Hot Water | 27517.3 | 0.0492126 | 33 | 214.287 | 7914.47 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 583.936 | 0.0416667 | 3144
710485 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 13534.4 | 0.0492126 | 35 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 287.209 | 0.0416667 | 3145
710513 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 14273.7 | 0.0656168 | 412 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 227.173 | 0.0625 | 3146
710520 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 44226.1 | 0.104987 | 413 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 439.925 | 0.104167 | 3147
710524 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 110876 | 0.0656168 | 73 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1764.64 | 0.0625 | 3148
710533 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 127239 | 0.0656168 | 73 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 2025.08 | 0.0625 | 3149
710605 | Level 1 | Piping System: Domestic Hot Water 1 | -282.538 | Domestic Hot Water 1 | Domestic Hot Water | 73959 | 0.0656168 | 73 | -282.538 |  | 894.556 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1177.09 | 0.0625 | 3151
710643 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 58667.7 | 0.0656168 | 72 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 933.725 | 0.0625 | 3153
710650 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 127351 | 0.0656168 | 412 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 2026.85 | 0.0625 | 3154
710652 | Level 1 | Piping System: Domestic Hot Water 1 | 191.895 | Domestic Hot Water 1 | Domestic Hot Water | 1580.66 | 0.0656168 | 72 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 25.157 | 0.0625 | 3155
710684 | Level 1 | Piping System: Domestic Hot Water 1 | -282.538 | Domestic Hot Water 1 | Domestic Hot Water | 29221.5 | 0.0656168 | 72 | -282.538 |  | 182.538 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 465.075 | 0.0625 | 3156
710688 | Level 1 | Piping System: Domestic Hot Water 1 | 191.895 | Domestic Hot Water 1 | Domestic Hot Water | 2572.24 | 0.0656168 | 72 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 40.9385 | 0.0625 | 3157
710696 | Level 1 | Piping System: Domestic Hot Water 1 | 214.287 | Domestic Hot Water 1 | Domestic Hot Water | 27517.3 | 0.0492126 | 71 | 214.287 |  | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 583.936 | 0.0416667 | 3158
710737 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 22084.4 | 0.0656168 | 410 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 351.484 | 0.0625 | 3159
710819 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 91621.6 | 0.0492126 | 417 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1944.27 | 0.0416667 | 3160
710824 | Level 1 | Piping System: Domestic Hot Water 1 | -314.245 | Domestic Hot Water 1 | Domestic Hot Water | 704958 | 0.104987 | 349 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 11216.5 | 0 | 0 | 0 | 0 | 0 | 0.0934711 | 32 mmø | 7012.34 | 0.104167 | 3161
710828 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 2154.15 | 0.0492126 | 417 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 45.7125 | 0.0416667 | 3162
710872 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 417 | -285.713 |  | 185.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 3163
710907 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 23856.9 | 0.0492126 | 415 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 506.259 | 0.0416667 | 3164
710956 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 15410.8 | 0.082021 | 423 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 196.216 | 0.0833333 | 3165
710965 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 135268 | 0.0656168 | 348 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 2152.86 | 0.0625 | 3166
710969 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 167631 | 0.0656168 | 86 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 2667.93 | 0.0625 | 3167
710995 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 72747.1 | 0.0492126 | 83 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1543.74 | 0.0416667 | 3168
711027 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 5417.06 | 0.0492126 | 83 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 114.954 | 0.0416667 | 3169
711083 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 83 | -285.713 |  | 185.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 3170
711089 | Level 1 | Piping System: Domestic Hot Water 1 | 214.288 | Domestic Hot Water 1 | Domestic Hot Water | 27517.3 | 0.0492126 | 83 | 214.288 |  | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 583.936 | 0.0416667 | 3171
711107 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 15737.7 | 0.0492126 | 85 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 333.964 | 0.0416667 | 3172
711125 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 92468.6 | 0.0492126 | 78 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 1962.24 | 0.0416667 | 3173
711132 | Level 1 | Piping System: Domestic Hot Water 1 | -308.105 | Domestic Hot Water 1 | Domestic Hot Water | 135707 | 0.0656168 | 422 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 2159.84 | 0.0625 | 3174
711136 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 4772.68 | 0.0492126 | 78 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 101.279 | 0.0416667 | 3175
711162 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 78 | -285.713 |  | 185.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 3176
711168 | Level 1 | Piping System: Domestic Hot Water 1 | 218.256 | Domestic Hot Water 1 | Domestic Hot Water | 27330.3 | 0.0492126 | 77 | 218.256 |  | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 579.967 | 0.0416667 | 3177
711174 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 12429.4 | 0.0492126 | 88 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 263.761 | 0.0416667 | 3178
711181 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 177580 | 0.082021 | 424 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 2261.02 | 0.0833333 | 3179
711185 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 1472.06 | 0.0492126 | 88 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 31.2381 | 0.0416667 | 3180
711231 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 88 | -285.713 |  | 185.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 3181
711235 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 5066.95 | 0.0492126 | 88 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 107.524 | 0.0416667 | 3182
711243 | Level 1 | Piping System: Domestic Hot Water 1 | 214.289 | Domestic Hot Water 1 | Domestic Hot Water | 27517.2 | 0.0492126 | 88 | 214.29 | 5212.45 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 583.934 | 0.0416667 | 3183
711253 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 140764 | 0.0492126 | 18 | -300 | 0 | -300 | Level: Level 1 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 8627.34 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 2987.11 | 0.0416667 | 3184
711260 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 237256 | 0.082021 | 425 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 3020.84 | 0.0833333 | 3185
711264 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 1015.8 | 0.0492126 | 18 | 200 | 0 | 200 | Level: Level 1 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 62.2577 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 21.5559 | 0.0416667 | 3186
711332 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 18 | -285.713 |  | 185.713 | Level: Level 1 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 1361.57 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 3187
711443 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 22106.4 | 0.0492126 | 80 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 469.112 | 0.0416667 | 3188
711464 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 23695.4 | 0.0492126 | 90 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 502.833 | 0.0416667 | 3189
711497 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 31676.1 | 0.0492126 | 20 | -300 | 0 | -300 | Level: Level 1 | 85405.1 | 2 | 880.322 | 4196.85 | 12.4658 | 0.0142324 | 1941.41 | 2.25 | 0.0119756 | 0.0349738 | 15 mmø | 672.188 | 0.0416667 | 3190
711565 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 141251 | 0.0492126 | 93 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 2997.43 | 0.0416667 | 3191
711572 | Level 1 | Piping System: Domestic Hot Water 1 | -311.28 | Domestic Hot Water 1 | Domestic Hot Water | 378835 | 0.082021 | 419 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 4823.48 | 0.0833333 | 3192
711576 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 538.39 | 0.0492126 | 93 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 11.425 | 0.0416667 | 3193
711611 | Level 1 | Piping System: Domestic Hot Water 1 | -285.713 | Domestic Hot Water 1 | Domestic Hot Water | 22215.4 | 0.0492126 | 93 | -285.713 |  | 185.713 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 471.425 | 0.0416667 | 3194
711615 | Level 1 | Piping System: Domestic Hot Water 1 | 194.67 | Domestic Hot Water 1 | Domestic Hot Water | 2837.99 | 0.0492126 | 93 | 200 | 0 | 200 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 60.224 | 0.0416667 | 3195
711623 | Level 1 | Piping System: Domestic Hot Water 1 | 214.289 | Domestic Hot Water 1 | Domestic Hot Water | 27517.2 | 0.0492126 | 93 | 214.29 | 5212.45 | 798.223 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 583.934 | 0.0416667 | 3196
711669 | Level 1 | Piping System: Domestic Hot Water 1 | -305.33 | Domestic Hot Water 1 | Domestic Hot Water | 22452.7 | 0.0492126 | 95 | -300 | 0 | -300 | Level: Level 1 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 476.461 | 0.0416667 | 3197
711781 | Level 2 | Piping System: Domestic Hot Water 1 | 3052.58 | Domestic Hot Water 1 | Domestic Hot Water | 154938 | 0.131234 | 447 | -1500 | 0 | -1500 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 1232.96 | 0.125 | 3199
711785 | Level 2 | Piping System: Domestic Hot Water 1 | 3122.58 | Domestic Hot Water 1 | Domestic Hot Water | 138081 | 0.131234 | 426 | -1430 | 0 | -1430 | Level: Level 2 | 0 | 0 | 0 | 13716.5 | 0 | 0 | 0 | 0 | 0 | 0.114304 | 40 mmø | 1098.82 | 0.125 | 3200
711816 | Level 2 | Piping System: Domestic Hot Water 1 | 3128.72 | Domestic Hot Water 1 | Domestic Hot Water | 403994 | 0.082021 | 433 | -1430 | 0 | -1430 | Level: Level 2 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 5143.81 | 0.0833333 | 3201
711855 | Level 2 | Piping System: Domestic Hot Water 1 | 3158.72 | Domestic Hot Water 1 | Domestic Hot Water | 150012 | 0.082021 | 430 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 8881.89 | 0 | 0 | 0 | 0 | 0 | 0.0740157 | 25 mmø | 1910.01 | 0.0833333 | 3202
711913 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 28583.6 | 0.0656168 | 427 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 454.922 | 0.0625 | 3203
711944 | Level 2 | Piping System: Domestic Hot Water 1 | 4861.9 | Domestic Hot Water 1 | Domestic Hot Water | 9113.05 | 0.0656168 | 681 | 300 | 0 | 300 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 145.039 | 0.0625 | 3204
712188 | Level 2 | Piping System: Domestic Hot Water 1 | 3187.46 | Domestic Hot Water 1 | Domestic Hot Water | 104620 | 0.0656168 | 427 | -1382.54 |  | 282.538 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1665.08 | 0.0625 | 3205
712193 | Level 2 | Piping System: Domestic Hot Water 1 | 4861.9 | Domestic Hot Water 1 | Domestic Hot Water | 9862.84 | 0.0656168 | 681 | 300 | 0 | 300 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 156.972 | 0.0625 | 3206
712204 | Level 2 | Piping System: Domestic Hot Water 1 | 4861.9 | Domestic Hot Water 1 | Domestic Hot Water | 11229.6 | 0.0656168 | 683 | 300 | 0 | 300 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 178.725 | 0.0625 | 3208
712209 | Level 2 | Piping System: Domestic Hot Water 1 | 4861.9 | Domestic Hot Water 1 | Domestic Hot Water | 63722.8 | 0.0656168 | 427 | 300 | 0 | 300 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 1014.18 | 0.0625 | 3209
712210 | Level 2 | Piping System: Domestic Hot Water 1 | 4861.9 | Domestic Hot Water 1 | Domestic Hot Water | 15895.7 | 0.0656168 | 683 | 300 | 0 | 300 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 252.989 | 0.0625 | 3210
712217 | Level 2 | Piping System: Domestic Hot Water 1 | 4861.9 | Domestic Hot Water 1 | Domestic Hot Water | 2474.2 | 0.0656168 | 683 | 300 | 0 | 300 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 39.3781 | 0.0625 | 3211
712272 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 1000.07 | 0.0656168 | 640 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 15.9166 | 0.0625 | 3213
712334 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 889.984 | 0.0656168 | 640 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 14.1645 | 0.0625 | 3214
712340 | Level 2 | Piping System: Domestic Hot Water 1 | 3211.9 | Domestic Hot Water 1 | Domestic Hot Water | 152372 | 0.0656168 | 640 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 2425.08 | 0.0625 | 3215
712608 | Level 2 | Piping System: Domestic Hot Water 1 | 3187.46 | Domestic Hot Water 1 | Domestic Hot Water | 947.19 | 0.0656168 | 640 | -1367.46 |  | -1382.54 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 15.075 | 0.0625 | 3216
712685 | Level 2 | Piping System: Domestic Hot Water 1 | 3161.9 | Domestic Hot Water 1 | Domestic Hot Water | 13100.2 | 0.0656168 | 431 | -1400 | 0 | -1400 | Level: Level 2 | 0 | 0 | 0 | 6381.89 | 0 | 0 | 0 | 0 | 0 | 0.0531824 | 20 mmø | 208.497 | 0.0625 | 3218
712726 | Level 2 | Piping System: Domestic Hot Water 1 | 3214.67 | Domestic Hot Water 1 | Domestic Hot Water | 469892 | 0.0492126 | 646 | -1350 | 0 | -1350 | Level: Level 2 | 0 | 0 | 0 | 4196.85 | 0 | 0 | 0 | 0 | 0 | 0.0349738 | 15 mmø | 9971.43 | 0.0416667 | 3219
