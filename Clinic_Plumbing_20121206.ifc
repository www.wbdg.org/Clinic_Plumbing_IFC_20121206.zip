Properties of the parts of a building model (IFC2X3), part 26 of 29

# IfcFlowSegment: Pipe Types:Storm:721624 (80)
Other - Classification Code: 23-60 30 11 11; Color: White; Reference: Type A - 1; Classification Description: Pipes for General Use; WarrantyDescription: N/A; Grade: N/A; AccessibilityPerformance: N/A; Shape: N/A; Material: Material; ModelLabel: N/A; Constituents: N/A; CodePerformance: N/A; SustainabilityPerformance: N/A; ProductionYear: N/A; Size: Size; NominalWidth: 0; WarrantyDurationParts: N/A; WarrantyGuarantorParts: N/A; Features: N/A; AssetAccountingType: FIXED; NominalLength: 0; WarrantyDurationLabor: N/A; ReplacementCost: N/A; ExpectedLife: N/A; ModelReference: N/A; WarrantyGuarantorLabor: N/A; NominalHeight: 0; WarrantyStartDate: N/A; BarCode: N/A; TagNumber: N/A; InstallationDate: N/A; AssetIdentifier: N/A; SerialNumber: N/A
Mechanical - Material: Plastic; Roughness: 0.00000833333; Connection Type: Generic; Pipe Segment: Plastic - Schedule 40; Schedule/Type: Pipe Schedule Types: Schedule 40
Constraints - Horizontal Justification: 0; Vertical Justification: 0
Phasing - Phase Created: New Construction
Name (Pipe Types:Storm:...) | In | Area (mm2) | System Classification | Diameter | Section | Invert Elevation (mm) | Relative Roughness | Additional Flow | Reference Level | Slope | Offset (mm) = Start Offset (mm) | End Offset (mm) | Mark | Size = Overall Size | Length (mm) | Inner Diameter | Outer Diameter | System Name | System Type
721624 | Level 2 | 3572468 | Undefined | 0.492126 | 0 | 4042.12 | 66050 | 0 | Level: Level 2 | 0 | -444 | -444 | 3509 | 150 mmø | 7581.01 | 0.550417 | 0.552083 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
721628 | Level 2 | 108525 | Undefined | 0.492126 | 0 | 4042.12 | 66050 | 0 | Level: Level 2 | 0 | -444 | -444 | 3510 | 150 mmø | 230.298 | 0.550417 | 0.552083 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
721635 | Level 2 | 528264 | Undefined | 0.492126 | 0 | 4042.12 | 66050 | 0 | Level: Level 2 | 0 | -444 | -444 | 3511 | 150 mmø | 1121.01 | 0.550417 | 0.552083 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
721640 | Level 1 | 199140 | Undefined | 0.492126 | 0 | 216.116 | 66050 | 0 | Level: Level 1 | 0 | 300 | 300 | 3512 | 150 mmø | 422.588 | 0.550417 | 0.552083 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
721691 | Level 2 | 1723662 | Undefined | 0.492126 | 0 | 384.137 | 66050 | 0 | Level: Level 2 |  | -528.138 | -4185.86 | 3513 | 150 mmø | 3657.73 | 0.550417 | 0.552083 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
721970 | Level 2 | 281085 | Undefined | 0.328084 | 0 | 3613.87 | 40260 | 0 | Level: Level 2 | 0 | -905 | -905 | 3518 | 100 mmø | 894.723 | 0.3355 | 0.375 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
722008 | Level 2 | 265861 | Undefined | 0.328084 | 0 | 3723.74 | 40260 | 0 | Level: Level 2 |  | -846.263 | 0 | 3520 | 100 mmø | 846.263 | 0.3355 | 0.375 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
722025 | Level 1 | 71439 | Undefined | 0.262467 | 0 | 261.036 | 30680 | 0 | Level: Level 1 | 0 | 300 | 300 | 3521 | 80 mmø | 284.247 | 0.255667 | 0.291667 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
722029 | Level 2 | 300642 | Undefined | 0.262467 | 0 | 4087.04 | 30680 | 0 | Level: Level 2 | 0 | -444 | -444 | 3522 | 80 mmø | 1196.22 | 0.255667 | 0.291667 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
722090 | Level 1 | 938438 | Undefined | 0.262467 | 0 | 346.037 | 30680 | 0 | Level: Level 1 |  | 346.038 | 4079.96 | 3523 | 80 mmø | 3733.93 | 0.255667 | 0.291667 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
722095 | Level 1 | 100766 | Undefined | 0.262467 | 0 | 4087.04 | 30680 | 0 | Level: Level 1 | 0 | 4126 | 4126 | 3524 | 80 mmø | 400.937 | 0.255667 | 0.291667 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
722241 | Level 2 | 144910 | Other | 0.328084 | 29 | 4818.87 | 40260 |  | Level: Level 2 | 0 | 300 | 300 | 3530 | 100 mmø | 461.263 | 0.3355 | 0.375 | Storm | Piping System: Storm
722401 | Level 2 | 3142449 | Undefined | 0.492126 | 0 | 3581.12 | 66050 | 0 | Level: Level 2 | 0 | -905 | -905 | 3532 | 150 mmø | 6668.48 | 0.550417 | 0.552083 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
722404 | Level 2 | 367799 | Undefined | 0.492126 | 0 | 3581.12 | 66050 | 0 | Level: Level 2 | 0 | -905 | -905 | 3534 | 150 mmø | 780.493 | 0.550417 | 0.552083 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
722408 | Level 2 | 386822 | Undefined | 0.492126 | 0 | 3749.14 | 66050 | 0 | Level: Level 2 |  | -820.863 | 0 | 3536 | 150 mmø | 820.863 | 0.550417 | 0.552083 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
723064 | Level 2 | 100019 | Undefined | 0.262467 | 0 | 4172.04 | 30680 | 0 | Level: Level 2 |  | -397.963 | 0 | 3540 | 80 mmø | 397.963 | 0.255667 | 0.291667 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
723376 | Level 2 | 138627 | Other | 0.328084 | 30 | 4818.87 | 40260 |  | Level: Level 2 | 0 | 300 | 300 | 3554 | 100 mmø | 441.263 | 0.3355 | 0.375 | Storm | Piping System: Storm
723976 | Level 2 | 214624 | Undefined | 0.262467 | 0 | 3626.04 | 30680 | 0 | Level: Level 2 | 0 | -905 | -905 | 3559 | 80 mmø | 853.963 | 0.255667 | 0.291667 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
724006 | Level 2 | 215881 | Undefined | 0.262467 | 0 | 3711.04 | 30680 | 0 | Level: Level 2 |  | -858.963 | 0 | 3561 | 80 mmø | 858.963 | 0.255667 | 0.291667 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
724018 | Level 2 | 879024 | Undefined | 0.262467 | 0 | 4087.04 | 30680 | 0 | Level: Level 2 | 0 | -444 | -444 | 3562 | 80 mmø | 3497.53 | 0.255667 | 0.291667 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
724044 | Level 1 | 37863.1 | Undefined | 0.262467 | 0 | 4087.04 | 30680 | 0 | Level: Level 1 | 0 | 4126 | 4126 | 3567 | 80 mmø | 150.652 | 0.255667 | 0.291667 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
724050 | Level 1 | 410893 | Undefined | 0.262467 | 0 | 4087.04 | 30680 | 0 | Level: Level 1 | 0 | 4126 | 4126 | 3568 | 80 mmø | 1634.89 | 0.255667 | 0.291667 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
724061 | Level 1 | 25823.1 | Undefined | 0.262467 | 0 | 261.036 | 30680 | 0 | Level: Level 1 | 0 | 300 | 300 | 3569 | 80 mmø | 102.747 | 0.255667 | 0.291667 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
724092 | Level 1 | 938438 | Undefined | 0.262467 | 0 | 346.037 | 30680 | 0 | Level: Level 1 |  | 4079.96 | 346.038 | 3570 | 80 mmø | 3733.93 | 0.255667 | 0.291667 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
724280 | Level 2 | 100019 | Undefined | 0.262467 | 0 | 4172.04 | 30680 | 0 | Level: Level 2 |  | -397.963 | 0 | 3572 | 80 mmø | 397.963 | 0.255667 | 0.291667 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
724546 | Level 2 | 860081 | Other | 0.492126 | 31 | 4042.12 | 66050 |  | Level: Level 2 | 0 | -444 | -444 | 3576 | 150 mmø | 1825.15 | 0.550417 | 0.552083 | Storm | Piping System: Storm
724554 | Level 2 | 61401.6 | Other | 0.492126 | 32 | 4042.12 | 66050 | 0 | Level: Level 2 | 0 | -444 | -444 | 3577 | 150 mmø | 130.298 | 0.550417 | 0.552083 | Storm | Piping System: Storm
724560 | Level 2 | 1992191 | Other | 0.492126 | 32 | 4042.12 | 66050 | 0 | Level: Level 2 | 0 | -444 | -444 | 3578 | 150 mmø | 4227.56 | 0.550417 | 0.552083 | Storm | Piping System: Storm
724748 | Level 2 | 64615.2 | Other | 0.262467 | 33 | 4087.04 | 30680 |  | Level: Level 2 | 0 | -444 | -444 | 3584 | 80 mmø | 257.096 | 0.255667 | 0.291667 | Storm | Piping System: Storm
724833 | Level 2 | 60552.5 | Other | 0.262467 | 34 | 4087.04 | 30680 |  | Level: Level 2 | 0 | -444 | -444 | 3589 | 80 mmø | 240.931 | 0.255667 | 0.291667 | Storm | Piping System: Storm
724879 | Level 2 | 284675 | Other | 0.262467 | 35 | 4087.04 | 30680 | 0 | Level: Level 2 | 0 | -444 | -444 | 3590 | 80 mmø | 1132.69 | 0.255667 | 0.291667 | Storm | Piping System: Storm
724888 | Level 2 | 69088.2 | Other | 0.262467 | 39 | 4087.04 | 30680 | 0 | Level: Level 2 | 0 | -444 | -444 | 3591 | 80 mmø | 274.893 | 0.255667 | 0.291667 | Storm | Piping System: Storm
724920 | Level 1 | 114093 | Other | 0.262467 | 36 | 261.036 | 30680 |  | Level: Level 1 | 0 | 300 | 300 | 3592 | 80 mmø | 453.963 | 0.255667 | 0.291667 | Storm | Piping System: Storm
724931 | Level 2 | 938438 | Other | 0.262467 | 39 | 346.037 | 30680 | 0 | Level: Level 2 |  | -490.037 | -4223.96 | 3593 | 80 mmø | 3733.93 | 0.255667 | 0.291667 | Storm | Piping System: Storm
725095 | Level 2 | 301853 | Other | 0.262467 | 37 | 4087.04 | 30680 | 0 | Level: Level 2 | 0 | -444 | -444 | 3595 | 80 mmø | 1201.04 | 0.255667 | 0.291667 | Storm | Piping System: Storm
725148 | Level 2 | 301241 | Other | 0.262467 | 38 | 4087.04 | 30680 | 0 | Level: Level 2 | 0 | -444 | -444 | 3600 | 80 mmø | 1198.6 | 0.255667 | 0.291667 | Storm | Piping System: Storm
725223 | Level 2 | 131777 | Other | 0.262467 | 51 | 3626.04 | 30680 | 0 | Level: Level 2 | 0 | -905 | -905 | 3605 | 80 mmø | 524.325 | 0.255667 | 0.291667 | Storm | Piping System: Storm
725236 | Level 2 | 1967225 | Other | 0.262467 | 51 | 3626.04 | 30680 | 0 | Level: Level 2 | 0 | -905 | -905 | 3607 | 80 mmø | 7827.34 | 0.255667 | 0.291667 | Storm | Piping System: Storm
725245 | Level 2 | 141374 | Other | 0.262467 | 51 | 3626.04 | 30680 | 0 | Level: Level 2 | 0 | -905 | -905 | 3608 | 80 mmø | 562.511 | 0.255667 | 0.291667 | Storm | Piping System: Storm
725255 | Level 2 | 422595 | Other | 0.262467 | 51 | 3626.04 | 30680 | 0 | Level: Level 2 | 0 | -905 | -905 | 3609 | 80 mmø | 1681.45 | 0.255667 | 0.291667 | Storm | Piping System: Storm
725269 | Level 2 | 118332 | Other | 0.262467 | 51 | 3626.04 | 30680 | 0 | Level: Level 2 | 0 | -905 | -905 | 3610 | 80 mmø | 470.828 | 0.255667 | 0.291667 | Storm | Piping System: Storm
725454 | Level 2 | 1372540 | Other | 0.262467 | 39 | 4087.04 | 30680 | 0 | Level: Level 2 | 0 | -444 | -444 | 3617 | 80 mmø | 5461.16 | 0.255667 | 0.291667 | Storm | Piping System: Storm
725459 | Level 2 | 125277 | Other | 0.262467 | 40 | 4087.04 | 30680 | 0 | Level: Level 2 | 0 | -444 | -444 | 3618 | 80 mmø | 498.463 | 0.255667 | 0.291667 | Storm | Piping System: Storm
725462 | Level 2 | 99176 | Other | 0.262467 | 47 | 4087.04 | 30680 | 0 | Level: Level 2 | 0 | -444 | -444 | 3619 | 80 mmø | 394.609 | 0.255667 | 0.291667 | Storm | Piping System: Storm
725468 | Level 2 | 967789 | Other | 0.262467 | 41 | 4087.04 | 30680 | 0 | Level: Level 2 | 0 | -444 | -444 | 3620 | 80 mmø | 3850.71 | 0.255667 | 0.291667 | Storm | Piping System: Storm
725551 | Level 2 | 253450 | Other | 0.262467 | 45 | 3981.04 | 30680 | 0 | Level: Level 2 | 0 | -550 | -550 | 3623 | 80 mmø | 1008.45 | 0.255667 | 0.291667 | Storm | Piping System: Storm
725557 | Level 2 | 1160329 | Other | 0.262467 | 42 | 3981.04 | 30680 | 0 | Level: Level 2 | 0 | -550 | -550 | 3624 | 80 mmø | 4616.8 | 0.255667 | 0.291667 | Storm | Piping System: Storm
726133 | Level 2 | 680576 | Other | 0.262467 | 42 | 3981.04 | 30680 | 0 | Level: Level 2 | 0 | -550 | -550 | 3632 | 80 mmø | 2707.93 | 0.255667 | 0.291667 | Storm | Piping System: Storm
726173 | Level 2 | 57283.8 | Other | 0.262467 | 42 | 3981.04 | 30680 | 0 | Level: Level 2 | 0 | -550 | -550 | 3633 | 80 mmø | 227.925 | 0.255667 | 0.291667 | Storm | Piping System: Storm
726235 | Level 1 | 113760 | Other | 0.262467 | 43 | 261.036 | 30680 |  | Level: Level 1 | 0 | 300 | 300 | 3634 | 80 mmø | 452.639 | 0.255667 | 0.291667 | Storm | Piping System: Storm
726244 | Level 2 | 938438 | Other | 0.262467 | 41 | 346.037 | 30680 | 0 | Level: Level 2 |  | -490.037 | -4223.96 | 3635 | 80 mmø | 3733.93 | 0.255667 | 0.291667 | Storm | Piping System: Storm
726282 | Level 2 | 224475 | Other | 0.262467 | 44 | 3981.04 | 30680 | 0 | Level: Level 2 | 0 | -550 | -550 | 3636 | 80 mmø | 893.159 | 0.255667 | 0.291667 | Storm | Piping System: Storm
726288 | Level 2 | 121170 | Other | 0.262467 | 44 | 3981.04 | 30680 | 0 | Level: Level 2 | 0 | -550 | -550 | 3637 | 80 mmø | 482.119 | 0.255667 | 0.291667 | Storm | Piping System: Storm
726323 | Level 2 | 2114907 | Other | 0.262467 | 45 | 3981.04 | 30680 | 0 | Level: Level 2 | 0 | -550 | -550 | 3639 | 80 mmø | 8414.95 | 0.255667 | 0.291667 | Storm | Piping System: Storm
726343 | Level 2 | 178505 | Other | 0.262467 | 46 | 4087.04 | 30680 | 0 | Level: Level 2 | 0 | -444 | -444 | 3640 | 80 mmø | 710.25 | 0.255667 | 0.291667 | Storm | Piping System: Storm
726349 | Level 2 | 54245.8 | Other | 0.262467 | 46 | 4087.04 | 30680 | 0 | Level: Level 2 | 0 | -444 | -444 | 3641 | 80 mmø | 215.837 | 0.255667 | 0.291667 | Storm | Piping System: Storm
726388 | Level 2 | 2387505 | Other | 0.262467 | 47 | 4087.04 | 30680 | 0 | Level: Level 2 | 0 | -444 | -444 | 3643 | 80 mmø | 9499.58 | 0.255667 | 0.291667 | Storm | Piping System: Storm
726790 | Level 2 | 205764 | Other | 0.492126 | 48 | 4786.12 | 66050 |  | Level: Level 2 | 0 | 300 | 300 | 3655 | 150 mmø | 436.644 | 0.550417 | 0.552083 | Storm | Piping System: Storm
1073571 | Level 2 | 188713 | Sanitary | 0.492126 | 2 | 4786.12 | 66050 |  | Level: Level 2 | 0 | 300 | 300 | 5093 | 150 mmø | 400.461 | 0.550417 | 0.552083 | Sanitary 3 | Piping System: Sanitary | Mechanical - Flow - Fixture Units: 0
1073944 | Level 2 | 426293 | Undefined | 0.328084 | 0 | 4074.87 | 40260 | 0 | Level: Level 2 | 0 | -444 | -444 | 5097 | 100 mmø | 1356.93 | 0.3355 | 0.375 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
1073950 | Level 2 | 66394.5 | Undefined | 0.328084 | 0 | 4074.87 | 40260 | 0 | Level: Level 2 | 0 | -444 | -444 | 5098 | 100 mmø | 211.34 | 0.3355 | 0.375 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
1073959 | Level 2 | 746735 | Undefined | 0.328084 | 0 | 4074.87 | 40260 | 0 | Level: Level 2 | 0 | -444 | -444 | 5099 | 100 mmø | 2376.93 | 0.3355 | 0.375 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
1074042 | Level 2 | 121034 | Undefined | 0.328084 | 0 | 4184.74 | 40260 | 0 | Level: Level 2 |  | -385.263 | 0 | 5101 | 100 mmø | 385.263 | 0.3355 | 0.375 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
1074060 | Level 2 | 287898 | Undefined | 0.328084 | 0 | 3613.87 | 40260 | 0 | Level: Level 2 | 0 | -905 | -905 | 5102 | 100 mmø | 916.409 | 0.3355 | 0.375 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
1074122 | Level 2 | 265861 | Undefined | 0.328084 | 0 | 3723.74 | 40260 | 0 | Level: Level 2 |  | -846.263 | 0 | 5104 | 100 mmø | 846.263 | 0.3355 | 0.375 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
1074223 | Level 1 | 85365.6 | Undefined | 0.328084 | 0 | 248.87 | 40260 | 0 | Level: Level 1 | 0 | 300 | 300 | 5105 | 100 mmø | 271.727 | 0.3355 | 0.375 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
1074230 | Level 2 | 1165067 | Undefined | 0.328084 | 0 | 358.737 | 40260 | 0 | Level: Level 2 |  | -502.737 | -4211.26 | 5106 | 100 mmø | 3708.53 | 0.3355 | 0.375 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
1074634 | Level 2 | 409659 | Undefined | 0.492126 | 0 | 3581.12 | 66050 | 0 | Level: Level 2 | 0 | -905 | -905 | 5110 | 150 mmø | 869.323 | 0.550417 | 0.552083 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
1074670 | Level 2 | 386822 | Undefined | 0.492126 | 0 | 3749.14 | 66050 | 0 | Level: Level 2 |  | -820.863 | 0 | 5112 | 150 mmø | 820.863 | 0.550417 | 0.552083 | Mechanical - Flow - Pressure Drop: 0; Friction: 0; Velocity: 0; Reynolds Number: 0; Fixture Units: 0; Flow: 0; Friction Factor: 0; Flow State: 0
1074680 | Level 2 | 650786 | Other | 0.492126 | 19 | 3886.12 | 66050 |  | Level: Level 2 | 0 | -600 | -600 | 5113 | 150 mmø | 1381.01 | 0.550417 | 0.552083 | Storm | Piping System: Storm
1074684 | Level 2 | 115223 | Other | 0.492126 | 19 | 3886.12 | 66050 |  | Level: Level 2 | 0 | -600 | -600 | 5114 | 150 mmø | 244.512 | 0.550417 | 0.552083 | Storm | Piping System: Storm
1074766 | Level 1 | 111632 | Other | 0.492126 | 19 | 216.116 | 66050 |  | Level: Level 1 | 0 | 300 | 300 | 5118 | 150 mmø | 236.89 | 0.550417 | 0.552083 | Storm | Piping System: Storm
1074777 | Level 2 | 1650149 | Other | 0.492126 | 19 | 384.137 | 66050 |  | Level: Level 2 |  | -684.138 | -4185.86 | 5119 | 150 mmø | 3501.73 | 0.550417 | 0.552083 | Storm | Piping System: Storm
1088230 | Level 2 | 71442.1 | Other | 0.262467 | 49 | 4831.04 | 30680 |  | Level: Level 2 | 0 | 300 | 300 | 5382 | 80 mmø | 284.259 | 0.255667 | 0.291667 | Storm | Piping System: Storm
1088641 | Level 1 | 93257.5 | Other | 0.262467 | 50 | 261.036 | 30680 |  | Level: Level 1 | 0 | 300 | 300 | 5389 | 80 mmø | 371.06 | 0.255667 | 0.291667 | Storm | Piping System: Storm
1088648 | Level 1 | 822576 | Other | 0.262467 | 51 | 346.037 | 30680 | 0 | Level: Level 1 |  | 3618.96 | 346.038 | 5390 | 80 mmø | 3272.93 | 0.255667 | 0.291667 | Storm | Piping System: Storm
1088726 | Level 1 | 93257.5 | Other | 0.262467 | 52 | 261.036 | 30680 |  | Level: Level 1 | 0 | 300 | 300 | 5391 | 80 mmø | 371.06 | 0.255667 | 0.291667 | Storm | Piping System: Storm
1088733 | Level 1 | 911797 | Other | 0.262467 | 42 | 346.037 | 30680 | 0 | Level: Level 1 |  | 3973.96 | 346.038 | 5392 | 80 mmø | 3627.93 | 0.255667 | 0.291667 | Storm | Piping System: Storm
1151021 | Level 1 | 71941.6 | Other | 0.492126 | 19 | 3990.64 | 66050 |  | Level: Level 1 |  | 4143.3 | 3990.64 | 5639 | 150 mmø | 152.665 | 0.550417 | 0.552083 | Storm | Piping System: Storm
1151022 | Level 1 | 914512 | Other | 0.492126 | 19 | 3886.12 | 66050 |  | Level: Level 1 | 0 | 3970 | 3970 | 5640 | 150 mmø | 1940.66 | 0.550417 | 0.552083 | Storm | Piping System: Storm

# IfcFlowSegment: Pipe Types:Vent:631357 (250)
Type - ElementType: Pipe Types:Vent:631357
Constraints - Horizontal Justification: 0; Vertical Justification: 0
Mechanical - System Classification: Sanitary; Pipe Segment: Plastic - Schedule 40; System Name: Sanitary 1; Connection Type: Generic; System Type: Piping System: Sanitary 1; Roughness: 0.00000833333; Schedule/Type: Pipe Schedule Types: Schedule 40; Material: Plastic
Phasing - Phase Created: New Construction
Text - NominalDiameter: 1; OuterDiameter: 1; Gradient: 0; InnerDiameter: 1; InvertElevation: 1; TemperatureRange: 0; FluidFlowLeakage: 0; WorkingPressure: 0; LeakageCurve: 0; InteriorRoughnessCoefficient: 0; PressureRange: 0
Other - TagNumber: N/A; SerialNumber: N/A; AssetIdentifier: N/A; BarCode: N/A; InstallationDate: N/A; WarrantyStartDate: N/A; NominalHeight: 0; ReplacementCost: N/A; NominalLength: 0; WarrantyDurationLabor: N/A; Constituents: N/A; Classification Code: 23-60 30 11 11; Shape: N/A; Classification Description: Pipes for General Use; AssetAccountingType: FIXED; Features: N/A; Size: Size; Color: White; WarrantyGuarantorParts: N/A; CodePerformance: N/A; Material: Material; WarrantyDescription: N/A; ModelLabel: N/A; NominalWidth: 0; ExpectedLife: N/A; AccessibilityPerformance: N/A; WarrantyDurationParts: N/A; ModelReference: N/A; Reference: Type A - 1; WarrantyGuarantorLabor: N/A; Grade: N/A; SustainabilityPerformance: N/A; ProductionYear: N/A
Identity Data - Manufacturer: N/A
Name (Pipe Types:Vent:...) | In | Slope | Reference Level | Start Offset (mm) = Offset (mm) | End Offset (mm) | Diameter | Area (mm2) | Section | Invert Elevation (mm) | Overall Size = Size | Mark | Inner Diameter | Outer Diameter | Length (mm) | Fixture Units | Relative Roughness
631357 | Level 1 | 0 | Level: Level 1 | -200 | -200 | 0.131234 | 46681.1 | 295 | -220.447 | 40 mmø | 460 | 0.134167 | 0.158333 | 371.477 | 0 | 16100
631385 | Level 1 | 0 | Level: Level 1 | -200 | -200 | 0.131234 | 89658.3 | 304 | -220.447 | 40 mmø | 463 | 0.134167 | 0.158333 | 713.478 | 0 | 16100
631394 | Level 1 | 0 | Level: Level 1 | -200 | -200 | 0.131234 | 267690 | 295 | -220.447 | 40 mmø | 464 | 0.134167 | 0.158333 | 2130.21 | 0 | 16100
631396 | Level 1 | 0 | Level: Level 1 | -200 | -200 | 0.131234 | 31527.3 | 304 | -220.447 | 40 mmø | 465 | 0.134167 | 0.158333 | 250.886 | 0 | 16100
631408 | Level 1 |  | Level: Level 1 | -446.819 | -226.987 | 0.131234 | 27624.8 | 304 | -446.819 | 40 mmø | 466 | 0.134167 | 0.158333 | 219.831 | 0 | 16100
631419 | Level 1 | 0 | Level: Level 1 | -200 | -200 | 0.131234 | 29621.8 | 303 | -220.447 | 40 mmø | 468 | 0.134167 | 0.158333 | 235.723 | 0 | 16100
631503 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 94343.3 | 288 | -320.447 | 40 mmø | 471 | 0.134167 | 0.158333 | 750.76 | 0 | 16100
631509 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 41877.3 | 288 | -320.447 | 40 mmø | 472 | 0.134167 | 0.158333 | 333.249 | 0 | 16100
631610 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 379444 | 288 | -320.447 | 40 mmø | 475 | 0.134167 | 0.158333 | 3019.52 | 0 | 16100
631628 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 26567.1 | 287 | -320.447 | 40 mmø | 477 | 0.134167 | 0.158333 | 211.415 | 0 | 16100
631875 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 61499.4 | 291 | -320.447 | 40 mmø | 486 | 0.134167 | 0.158333 | 489.397 | 0 | 16100
632124 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 20266.1 | 290 | -320.447 | 40 mmø | 492 | 0.134167 | 0.158333 | 161.273 | 0 | 16100
632260 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.164042 | 375636 | 271 | -326.251 | 50 mmø | 496 | 0.17225 | 0.197917 | 2391.38 | 0 | 20670
632267 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.164042 | 105035 | 271 | -326.251 | 50 mmø | 498 | 0.17225 | 0.197917 | 668.672 | 0 | 20670
632274 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.164042 | 29312.1 | 271 | -326.251 | 50 mmø | 499 | 0.17225 | 0.197917 | 186.606 | 0 | 20670
632286 | Level 1 |  | Level: Level 1 | -427.769 | -333.337 | 0.164042 | 14833.2 | 271 | -427.769 | 50 mmø | 500 | 0.17225 | 0.197917 | 94.4312 | 0 | 20670
632375 | Level 1 |  | Level: Level 1 | 2866.66 | 39.6875 | 0.164042 | 444060 | 250 | 39.6875 | 50 mmø | 505 | 0.17225 | 0.197917 | 2826.98 | 0 | 20670
632678 | Level 1 |  | Level: Level 1 | 2933.34 | 4336.66 | 0.164042 | 220434 | 577 | 2933.34 | 50 mmø | 517 | 0.17225 | 0.197917 | 1403.33 | 0 | 20670
634087 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.164042 | 114520 | 250 | 2873.75 | 50 mmø | 539 | 0.17225 | 0.197917 | 729.06 | 0 | 20670
634096 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.164042 | 204972 | 577 | 2873.75 | 50 mmø | 540 | 0.17225 | 0.197917 | 1304.89 | 0 | 20670
634734 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.164042 | 127346 | 270 | -326.251 | 50 mmø | 559 | 0.17225 | 0.197917 | 810.709 | 0 | 20670
634737 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.164042 | 16627.5 | 276 | -326.251 | 50 mmø | 560 | 0.17225 | 0.197917 | 105.854 | 0 | 20670
635225 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 360801 | 290 | -320.447 | 40 mmø | 572 | 0.134167 | 0.158333 | 2871.17 | 0 | 16100
635229 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 26658.1 | 287 | -320.447 | 40 mmø | 573 | 0.134167 | 0.158333 | 212.139 | 0 | 16100
635270 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 118563 | 289 | -320.447 | 40 mmø | 575 | 0.134167 | 0.158333 | 943.491 | 0 | 16100
635646 | Level 1 |  | Level: Level 1 | -427.769 | -226.987 | 0.131234 | 25230.9 | 295 | -427.769 | 40 mmø | 581 | 0.134167 | 0.158333 | 200.781 | 0 | 16100
635867 | Level 1 | 0 | Level: Level 1 | -200 | -200 | 0.131234 | 118207 | 303 | -220.447 | 40 mmø | 589 | 0.134167 | 0.158333 | 940.66 | 0 | 16100
641139 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 43836.9 | 397 | -320.447 | 40 mmø | 703 | 0.134167 | 0.158333 | 348.843 | 0 | 16100
641146 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 557732 | 402 | -320.447 | 40 mmø | 704 | 0.134167 | 0.158333 | 4438.29 | 0 | 16100
641150 | Level 1 |  | Level: Level 1 | -446.819 | -326.987 | 0.131234 | 15058.4 | 397 | -446.819 | 40 mmø | 705 | 0.134167 | 0.158333 | 119.831 | 0 | 16100
641159 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 64293.2 | 396 | -320.447 | 40 mmø | 707 | 0.134167 | 0.158333 | 511.629 | 0 | 16100
641182 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 80504.3 | 396 | -320.447 | 40 mmø | 708 | 0.134167 | 0.158333 | 640.633 | 0 | 16100
641192 | Level 1 |  | Level: Level 1 | -466.663 | -326.987 | 0.131234 | 17552.1 | 396 | -466.663 | 40 mmø | 709 | 0.134167 | 0.158333 | 139.675 | 0 | 16100
641212 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 101710 | 403 | -320.447 | 40 mmø | 711 | 0.134167 | 0.158333 | 809.381 | 0 | 16100
641234 | Level 1 |  | Level: Level 1 | -446.819 | -326.987 | 0.131234 | 15058.4 | 403 | -446.819 | 40 mmø | 713 | 0.134167 | 0.158333 | 119.831 | 0 | 16100
641243 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 134067 | 402 | -320.447 | 40 mmø | 715 | 0.134167 | 0.158333 | 1066.87 | 0 | 16100
641252 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 389881 | 405 | -320.447 | 40 mmø | 716 | 0.134167 | 0.158333 | 3102.58 | 0 | 16100
641260 | Level 1 |  | Level: Level 1 | -427.769 | -326.987 | 0.131234 | 12664.5 | 405 | -427.769 | 40 mmø | 718 | 0.134167 | 0.158333 | 100.781 | 0 | 16100
641269 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 446381 | 406 | -320.447 | 40 mmø | 720 | 0.134167 | 0.158333 | 3552.19 | 0 | 16100
641298 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 358174 | 420 | -320.447 | 40 mmø | 721 | 0.134167 | 0.158333 | 2850.26 | 0 | 16100
641349 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 16851.6 | 420 | -320.447 | 40 mmø | 722 | 0.134167 | 0.158333 | 134.101 | 0 | 16100
641361 | Level 1 |  | Level: Level 1 | -446.819 | -326.987 | 0.131234 | 15058.4 | 420 | -446.819 | 40 mmø | 723 | 0.134167 | 0.158333 | 119.831 | 0 | 16100
641505 | Level 1 | 0 | Level: Level 1 | -500 | -500 | 0.328084 | 56142 | 413 | -551.13 | 100 mmø | 726 | 0.3355 | 0.375 | 178.706 | 0 | 40260
641621 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 95005.5 | 418 | -320.447 | 40 mmø | 733 | 0.134167 | 0.158333 | 756.03 | 0 | 16100
641634 | Level 1 |  | Level: Level 1 | -446.819 | -326.987 | 0.131234 | 15058.4 | 418 | -446.819 | 40 mmø | 735 | 0.134167 | 0.158333 | 119.831 | 0 | 16100
641643 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 49251 | 419 | -320.447 | 40 mmø | 737 | 0.134167 | 0.158333 | 391.927 | 0 | 16100
641705 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 27186.6 | 419 | -320.447 | 40 mmø | 738 | 0.134167 | 0.158333 | 216.344 | 0 | 16100
641834 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 58035.8 | 422 | -320.447 | 40 mmø | 743 | 0.134167 | 0.158333 | 461.834 | 0 | 16100
641840 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 126595 | 422 | -320.447 | 40 mmø | 744 | 0.134167 | 0.158333 | 1007.41 | 0 | 16100
641851 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 22265.4 | 422 | -320.447 | 40 mmø | 745 | 0.134167 | 0.158333 | 177.183 | 0 | 16100
641935 | Level 1 |  | Level: Level 1 | -273.013 | 4870 | 0.131234 | 646290 | 422 | -273.013 | 40 mmø | 747 | 0.134167 | 0.158333 | 5143.01 | 0 | 16100
641976 | Level 1 |  | Level: Level 1 | -446.819 | -326.987 | 0.131234 | 15058.4 | 422 | -446.819 | 40 mmø | 748 | 0.134167 | 0.158333 | 119.831 | 0 | 16100
641998 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 22849.9 | 241 | -320.447 | 40 mmø | 750 | 0.134167 | 0.158333 | 181.834 | 0 | 16100
642007 | Level 1 |  | Level: Level 1 | -473.013 | -326.987 | 0.131234 | 18350 | 241 | -473.013 | 40 mmø | 751 | 0.134167 | 0.158333 | 146.025 | 0 | 16100
642012 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 221399 | 241 | -320.447 | 40 mmø | 752 | 0.134167 | 0.158333 | 1761.83 | 0 | 16100
642017 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 347062 | 241 | -320.447 | 40 mmø | 753 | 0.134167 | 0.158333 | 2761.83 | 0 | 16100
642032 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 34560.7 | 241 | -320.447 | 40 mmø | 754 | 0.134167 | 0.158333 | 275.026 | 0 | 16100
642106 | Level 1 |  | Level: Level 1 | -266.663 | 4870 | 0.131234 | 645492 | 425 | -266.663 | 40 mmø | 759 | 0.134167 | 0.158333 | 5136.66 | 0 | 16100
642109 | Level 1 |  | Level: Level 1 | -408.719 | -333.338 | 0.131234 | 9472.69 | 426 | -408.719 | 40 mmø | 760 | 0.134167 | 0.158333 | 75.3812 | 0 | 16100
642327 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.328084 | 46587 | 428 | 2848.87 | 100 mmø | 769 | 0.3355 | 0.375 | 148.291 | 0 | 40260
642334 | Level 1 |  | Level: Level 1 | -434.913 | 2841.26 | 0.328084 | 1029241 | 428 | -434.913 | 100 mmø | 770 | 0.3355 | 0.375 | 3276.18 | 0 | 40260
642339 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.328084 | 89601.1 | 428 | 2848.87 | 100 mmø | 772 | 0.3355 | 0.375 | 285.209 | 0 | 40260
642344 | Level 2 | 0 | Level: Level 2 | -1670 | -1670 | 0.328084 | 1332829 | 428 | 2848.87 | 100 mmø | 773 | 0.3355 | 0.375 | 4242.53 | 0 | 40260
642451 | Level 1 | 0 | Level: Level 1 | 3100 | 3100 | 0.328084 | 79106.7 | 429 | 3048.87 | 100 mmø | 776 | 0.3355 | 0.375 | 251.804 | 0 | 40260
642458 | Level 1 |  | Level: Level 1 | -434.912 | 3041.26 | 0.328084 | 1092073 | 429 | -434.913 | 100 mmø | 777 | 0.3355 | 0.375 | 3476.17 | 0 | 40260
642464 | Level 1 | 0 | Level: Level 1 | 3100 | 3100 | 0.328084 | 520664 | 429 | 3048.87 | 100 mmø | 779 | 0.3355 | 0.375 | 1657.32 | 0 | 40260
642568 | Level 1 | 0 | Level: Level 1 | 3100 | 3100 | 0.328084 | 206494 | 429 | 3048.87 | 100 mmø | 780 | 0.3355 | 0.375 | 657.291 | 0 | 40260
642609 | Level 1 |  | Level: Level 1 | 2958.74 | 3034.91 | 0.328084 | 23931.1 | 428 | 2958.74 | 100 mmø | 782 | 0.3355 | 0.375 | 76.175 | 0 | 40260
642623 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.328084 | 465749 | 432 | 2848.87 | 100 mmø | 783 | 0.3355 | 0.375 | 1482.53 | 0 | 40260
642628 | Level 1 |  | Level: Level 1 | -434.913 | 2841.26 | 0.328084 | 1029241 | 432 | -434.913 | 100 mmø | 784 | 0.3355 | 0.375 | 3276.18 | 0 | 40260
642676 | Level 1 |  | Level: Level 1 | 2958.74 | 4870 | 0.328084 | 600441 | 432 | 2958.74 | 100 mmø | 787 | 0.3355 | 0.375 | 1911.26 | 0 | 40260
642716 | Level 1 | 0 | Level: Level 1 | 3100 | 3100 | 0.164042 | 27953 | 609 | 3073.75 | 50 mmø | 788 | 0.17225 | 0.197917 | 177.954 | 0 | 20670
642723 | Level 1 |  | Level: Level 1 | -460.312 | 3066.66 | 0.164042 | 554016 | 609 | -460.313 | 50 mmø | 789 | 0.17225 | 0.197917 | 3526.97 | 0 | 20670
642733 | Level 1 | 0 | Level: Level 1 | 3100 | 3100 | 0.164042 | 538578 | 610 | 3073.75 | 50 mmø | 792 | 0.17225 | 0.197917 | 3428.7 | 0 | 20670
642785 | Level 1 | 0 | Level: Level 1 | 3100 | 3100 | 0.164042 | 61783.3 | 610 | 3073.75 | 50 mmø | 793 | 0.17225 | 0.197917 | 393.325 | 0 | 20670
642792 | Level 1 | 0 | Level: Level 1 | 3100 | 3100 | 0.164042 | 13637.7 | 610 | 3073.75 | 50 mmø | 794 | 0.17225 | 0.197917 | 86.82 | 0 | 20670
642802 | Level 1 |  | Level: Level 1 | 91.2813 | 3066.66 | 0.164042 | 467372 | 610 | 91.2812 | 50 mmø | 795 | 0.17225 | 0.197917 | 2975.38 | 0 | 20670
643363 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.131234 | 128934 | 444 | 2879.55 | 40 mmø | 817 | 0.134167 | 0.158333 | 1026.03 | 0 | 16100
643370 | Level 1 |  | Level: Level 1 | -446.819 | 2873.01 | 0.131234 | 417182 | 444 | -446.819 | 40 mmø | 818 | 0.134167 | 0.158333 | 3319.83 | 0 | 16100
643378 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.131234 | 21631.1 | 445 | 2879.55 | 40 mmø | 820 | 0.134167 | 0.158333 | 172.135 | 0 | 16100
643389 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.131234 | 515978 | 445 | 2879.55 | 40 mmø | 821 | 0.134167 | 0.158333 | 4106.03 | 0 | 16100
643494 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.131234 | 154025 | 445 | 2879.55 | 40 mmø | 822 | 0.134167 | 0.158333 | 1225.69 | 0 | 16100
643525 | Level 1 |  | Level: Level 1 | 2933.34 | 3973.01 | 0.131234 | 130649 | 446 | 2933.34 | 40 mmø | 824 | 0.134167 | 0.158333 | 1039.67 | 0 | 16100
643527 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.131234 | 52765.5 | 444 | 2879.55 | 40 mmø | 825 | 0.134167 | 0.158333 | 419.895 | 0 | 16100
643579 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 82405.6 | 451 | -320.447 | 40 mmø | 829 | 0.134167 | 0.158333 | 655.763 | 0 | 16100
643586 | Level 1 |  | Level: Level 1 | -446.819 | -326.987 | 0.131234 | 15058.4 | 451 | -446.819 | 40 mmø | 830 | 0.134167 | 0.158333 | 119.831 | 0 | 16100
643594 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 223114 | 451 | -320.447 | 40 mmø | 832 | 0.134167 | 0.158333 | 1775.48 | 0 | 16100
643610 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 430102 | 457 | -320.447 | 40 mmø | 833 | 0.134167 | 0.158333 | 3422.64 | 0 | 16100
643617 | Level 1 |  | Level: Level 1 | -446.819 | -326.987 | 0.131234 | 15058.4 | 455 | -446.819 | 40 mmø | 834 | 0.134167 | 0.158333 | 119.831 | 0 | 16100
643625 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 54080.2 | 455 | -320.447 | 40 mmø | 836 | 0.134167 | 0.158333 | 430.356 | 0 | 16100
643627 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 29361.8 | 456 | -320.447 | 40 mmø | 837 | 0.134167 | 0.158333 | 233.654 | 0 | 16100
643634 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 60521.7 | 834 | -320.447 | 40 mmø | 838 | 0.134167 | 0.158333 | 481.616 | 0 | 16100
643713 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 60277.7 | 834 | -320.447 | 40 mmø | 842 | 0.134167 | 0.158333 | 479.675 | 0 | 16100
643743 | Level 1 |  | Level: Level 1 | -273.013 | 4870 | 0.131234 | 646290 | 456 | -273.013 | 40 mmø | 844 | 0.134167 | 0.158333 | 5143.01 | 0 | 16100
644097 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.164042 | 180236 | 810 | -326.251 | 50 mmø | 855 | 0.17225 | 0.197917 | 1147.42 | 0 | 20670
644102 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.164042 | 62172.2 | 461 | -326.251 | 50 mmø | 856 | 0.17225 | 0.197917 | 395.8 | 0 | 20670
644162 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 573106 | 463 | -320.447 | 40 mmø | 859 | 0.134167 | 0.158333 | 4560.63 | 0 | 16100
644182 | Level 1 |  | Level: Level 1 | -446.819 | -326.987 | 0.131234 | 15058.4 | 463 | -446.819 | 40 mmø | 861 | 0.134167 | 0.158333 | 119.831 | 0 | 16100
644191 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.164042 | 378152 | 810 | -326.251 | 50 mmø | 863 | 0.17225 | 0.197917 | 2407.39 | 0 | 20670
644338 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.131234 | 53009.2 | 465 | 2879.55 | 40 mmø | 866 | 0.134167 | 0.158333 | 421.834 | 0 | 16100
644345 | Level 1 |  | Level: Level 1 | -474.136 | 2873.01 | 0.131234 | 420615 | 465 | -474.136 | 40 mmø | 867 | 0.134167 | 0.158333 | 3347.15 | 0 | 16100
644350 | Level 1 | 0 | Level: Level 1 | 3000 | 3000 | 0.131234 | 306279 | 468 | 2979.55 | 40 mmø | 868 | 0.134167 | 0.158333 | 2437.29 | 0 | 16100
644486 | Level 1 | 0 | Level: Level 1 | 3000 | 3000 | 0.131234 | 733943 | 468 | 2979.55 | 40 mmø | 869 | 0.134167 | 0.158333 | 5840.53 | 0 | 16100
644562 | Level 1 |  | Level: Level 1 | 3020.64 | 4870 | 0.131234 | 232398 | 468 | 3020.64 | 40 mmø | 873 | 0.134167 | 0.158333 | 1849.36 | 0 | 16100
644749 | Level 1 | 0 | Level: Level 1 | 3000 | 3000 | 0.131234 | 102213 | 469 | 2979.55 | 40 mmø | 874 | 0.134167 | 0.158333 | 813.389 | 0 | 16100
644754 | Level 1 |  | Level: Level 1 | 372.231 | 2973.01 | 0.131234 | 326824 | 469 | 372.231 | 40 mmø | 875 | 0.134167 | 0.158333 | 2600.78 | 0 | 16100
644763 | Level 1 | 0 | Level: Level 1 | 3000 | 3000 | 0.131234 | 41642.8 | 465 | 2979.55 | 40 mmø | 877 | 0.134167 | 0.158333 | 331.383 | 0 | 16100
644780 | Level 1 |  | Level: Level 1 | -436.036 | 2816.71 | 0.328084 | 1021881 | 619 | -436.036 | 100 mmø | 879 | 0.3355 | 0.375 | 3252.75 | 0 | 40260
644837 | Level 1 | 0 | Level: Level 1 | 600 | 600 | 0.164042 | 85932.8 | 474 | 573.749 | 50 mmø | 881 | 0.17225 | 0.197917 | 547.065 | 0 | 20670
644844 | Level 1 |  | Level: Level 1 | -461.436 | 566.662 | 0.164042 | 161493 | 627 | -461.436 | 50 mmø | 882 | 0.17225 | 0.197917 | 1028.1 | 0 | 20670
644907 | Level 1 |  | Level: Level 1 | 324.214 | 566.663 | 0.164042 | 38083.8 | 474 | 324.214 | 50 mmø | 884 | 0.17225 | 0.197917 | 242.449 | 0 | 20670
644928 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.164042 | 24010.2 | 477 | -326.251 | 50 mmø | 886 | 0.17225 | 0.197917 | 152.854 | 0 | 20670
644935 | Level 1 |  | Level: Level 1 | -461.436 | -333.337 | 0.164042 | 20121.7 | 477 | -461.436 | 50 mmø | 887 | 0.17225 | 0.197917 | 128.098 | 0 | 20670
644940 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.164042 | 109715 | 477 | -326.251 | 50 mmø | 889 | 0.17225 | 0.197917 | 698.469 | 0 | 20670
644947 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.164042 | 342939 | 477 | -326.251 | 50 mmø | 890 | 0.17225 | 0.197917 | 2183.22 | 0 | 20670
644955 | Level 1 |  | Level: Level 1 | 560.312 | -266.663 | 0.164042 | 129901 | 477 | -266.663 | 50 mmø | 891 | 0.17225 | 0.197917 | 826.975 | 0 | 20670
645086 | Level 1 | 0 | Level: Level 1 | 600 | 600 | 0.164042 | 15757.1 | 476 | 573.749 | 50 mmø | 893 | 0.17225 | 0.197917 | 100.313 | 0 | 20670
645174 | Level 1 |  | Level: Level 1 | 3136.66 | 639.688 | 0.164042 | 392224 | 628 | 639.687 | 50 mmø | 895 | 0.17225 | 0.197917 | 2496.98 | 0 | 20670
645346 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.164042 | 30293.4 | 480 | -326.251 | 50 mmø | 898 | 0.17225 | 0.197917 | 192.854 | 0 | 20670
645353 | Level 1 |  | Level: Level 1 | -409.842 | -333.337 | 0.164042 | 12017.3 | 480 | -409.842 | 50 mmø | 899 | 0.17225 | 0.197917 | 76.5047 | 0 | 20670
645361 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.164042 | 48214.6 | 480 | -326.251 | 50 mmø | 901 | 0.17225 | 0.197917 | 306.944 | 0 | 20670
645368 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.164042 | 47716 | 480 | -326.251 | 50 mmø | 902 | 0.17225 | 0.197917 | 303.769 | 0 | 20670
645388 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.164042 | 448891 | 480 | -326.251 | 50 mmø | 903 | 0.17225 | 0.197917 | 2857.73 | 0 | 20670
645394 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.164042 | 388613 | 480 | -326.251 | 50 mmø | 904 | 0.17225 | 0.197917 | 2473.99 | 0 | 20670
645533 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.131234 | 109513 | 482 | 2879.55 | 40 mmø | 907 | 0.134167 | 0.158333 | 871.477 | 0 | 16100
645540 | Level 1 |  | Level: Level 1 | -447.942 | 2873.01 | 0.131234 | 417323 | 482 | -447.942 | 40 mmø | 908 | 0.134167 | 0.158333 | 3320.95 | 0 | 16100
645548 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.131234 | 232664 | 482 | 2879.55 | 40 mmø | 910 | 0.134167 | 0.158333 | 1851.48 | 0 | 16100
645732 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.131234 | 53009.2 | 751 | 2879.55 | 40 mmø | 915 | 0.134167 | 0.158333 | 421.834 | 0 | 16100
645739 | Level 1 |  | Level: Level 1 | -474.136 | 2873.01 | 0.131234 | 420615 | 751 | -474.136 | 40 mmø | 916 | 0.134167 | 0.158333 | 3347.15 | 0 | 16100
645744 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.131234 | 200388 | 751 | 2879.55 | 40 mmø | 917 | 0.134167 | 0.158333 | 1594.63 | 0 | 16100
645785 | Level 1 |  | Level: Level 1 | 5043.01 | 3817.69 | 0.131234 | 153979 | 751 | 3817.69 | 40 mmø | 919 | 0.134167 | 0.158333 | 1225.33 | 0 | 16100
645804 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.104987 | 227806 | 486 | -317.526 | 32 mmø | 920 | 0.115 | 0.138333 | 2266.02 | 0 | 13800
645812 | Level 1 |  | Level: Level 1 | -427.769 | -323.812 | 0.104987 | 10450.8 | 486 | -427.769 | 32 mmø | 921 | 0.115 | 0.138333 | 103.956 | 0 | 13800
645848 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.104987 | 67492.8 | 490 | -317.526 | 32 mmø | 926 | 0.115 | 0.138333 | 671.363 | 0 | 13800
645855 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.104987 | 71833.5 | 487 | -317.526 | 32 mmø | 927 | 0.115 | 0.138333 | 714.541 | 0 | 13800
645857 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.104987 | 12475.4 | 490 | -317.526 | 32 mmø | 928 | 0.115 | 0.138333 | 124.095 | 0 | 13800
645865 | Level 1 |  | Level: Level 1 | -408.719 | -323.812 | 0.104987 | 8535.71 | 490 | -408.719 | 32 mmø | 929 | 0.115 | 0.138333 | 84.9062 | 0 | 13800
645920 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.104987 | 62050.4 | 491 | -317.526 | 32 mmø | 931 | 0.115 | 0.138333 | 617.226 | 0 | 13800
645924 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.104987 | 274349 | 492 | -317.526 | 32 mmø | 932 | 0.115 | 0.138333 | 2729 | 0 | 13800
645940 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.104987 | 20355.7 | 491 | -317.526 | 32 mmø | 933 | 0.115 | 0.138333 | 202.482 | 0 | 13800
645952 | Level 1 |  | Level: Level 1 | -446.819 | -323.812 | 0.104987 | 12365.9 | 491 | -446.819 | 32 mmø | 934 | 0.115 | 0.138333 | 123.006 | 0 | 13800
646068 | Level 1 |  | Level: Level 1 | -408.719 | -330.163 | 0.104987 | 7897.34 | 498 | -408.719 | 32 mmø | 938 | 0.115 | 0.138333 | 78.5562 | 0 | 13800
646087 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.104987 | 25520.4 | 730 | -317.526 | 32 mmø | 939 | 0.115 | 0.138333 | 253.856 | 0 | 13800
646094 | Level 1 |  | Level: Level 1 | -408.719 | -323.812 | 0.104987 | 8535.71 | 730 | -408.719 | 32 mmø | 940 | 0.115 | 0.138333 | 84.9063 | 0 | 13800
646103 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.104987 | 95371.7 | 730 | -317.526 | 32 mmø | 942 | 0.115 | 0.138333 | 948.679 | 0 | 13800
646118 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.104987 | 362424 | 730 | -317.526 | 32 mmø | 943 | 0.115 | 0.138333 | 3605.1 | 0 | 13800
646193 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 88527.9 | 508 | -320.447 | 40 mmø | 949 | 0.134167 | 0.158333 | 704.483 | 0 | 16100
646198 | Level 1 |  | Level: Level 1 | -447.942 | -326.987 | 0.131234 | 15199.6 | 508 | -447.942 | 40 mmø | 950 | 0.134167 | 0.158333 | 120.955 | 0 | 16100
646206 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 99662 | 507 | -320.447 | 40 mmø | 952 | 0.134167 | 0.158333 | 793.085 | 0 | 16100
646259 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 308632 | 506 | -320.447 | 40 mmø | 953 | 0.134167 | 0.158333 | 2456.02 | 0 | 16100
646268 | Level 1 |  | Level: Level 1 | -447.942 | -326.987 | 0.131234 | 15199.6 | 506 | -447.942 | 40 mmø | 954 | 0.134167 | 0.158333 | 120.955 | 0 | 16100
646277 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 99874.6 | 508 | -320.447 | 40 mmø | 956 | 0.134167 | 0.158333 | 794.777 | 0 | 16100
646396 | Level 1 |  | Level: Level 1 | -474.095 | -326.988 | 0.131234 | 18486.1 | 513 | -474.095 | 40 mmø | 960 | 0.134167 | 0.158333 | 147.107 | 0 | 16100
646402 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 248243 | 515 | -320.447 | 40 mmø | 961 | 0.134167 | 0.158333 | 1975.46 | 0 | 16100
646407 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 30349.4 | 513 | -320.447 | 40 mmø | 962 | 0.134167 | 0.158333 | 241.513 | 0 | 16100
646408 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 109011 | 515 | -320.447 | 40 mmø | 963 | 0.134167 | 0.158333 | 867.484 | 0 | 16100
646428 | Level 1 |  | Level: Level 1 | -447.942 | -326.987 | 0.131234 | 15199.6 | 515 | -447.942 | 40 mmø | 964 | 0.134167 | 0.158333 | 120.955 | 0 | 16100
646437 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 639807 | 517 | -320.447 | 40 mmø | 966 | 0.134167 | 0.158333 | 5091.42 | 0 | 16100
646447 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 35085.5 | 517 | -320.447 | 40 mmø | 968 | 0.134167 | 0.158333 | 279.202 | 0 | 16100
646585 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 45681.7 | 516 | -320.447 | 40 mmø | 972 | 0.134167 | 0.158333 | 363.523 | 0 | 16100
646649 | Level 1 |  | Level: Level 1 | 3203.34 | 3973.01 | 0.131234 | 96720.2 | 739 | 3203.34 | 40 mmø | 974 | 0.134167 | 0.158333 | 769.675 | 0 | 16100
646651 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 84612.5 | 518 | -320.447 | 40 mmø | 975 | 0.134167 | 0.158333 | 673.325 | 0 | 16100
646913 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.131234 | 24540.8 | 524 | 2879.55 | 40 mmø | 987 | 0.134167 | 0.158333 | 195.29 | 0 | 16100
646920 | Level 1 |  | Level: Level 1 | -473.013 | 2873.01 | 0.131234 | 420474 | 524 | -473.013 | 40 mmø | 988 | 0.134167 | 0.158333 | 3346.03 | 0 | 16100
646925 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.131234 | 120228 | 524 | 2879.55 | 40 mmø | 989 | 0.134167 | 0.158333 | 956.742 | 0 | 16100
647165 | Level 1 | 0 | Level: Level 1 | 3000 | 3000 | 0.131234 | 32903 | 670 | 2979.55 | 40 mmø | 997 | 0.134167 | 0.158333 | 261.834 | 0 | 16100
647178 | Level 1 | 0 | Level: Level 1 | 3000 | 3000 | 0.131234 | 276937 | 670 | 2979.55 | 40 mmø | 999 | 0.134167 | 0.158333 | 2203.79 | 0 | 16100
647183 | Level 1 | 0 | Level: Level 1 | 3000 | 3000 | 0.131234 | 390315 | 670 | 2979.55 | 40 mmø | 1000 | 0.134167 | 0.158333 | 3106.03 | 0 | 16100
647229 | Level 1 |  | Level: Level 1 | 3026.99 | 4870 | 0.131234 | 231600 | 670 | 3026.99 | 40 mmø | 1002 | 0.134167 | 0.158333 | 1843.01 | 0 | 16100
647240 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.131234 | 58571.7 | 528 | 2879.55 | 40 mmø | 1003 | 0.134167 | 0.158333 | 466.099 | 0 | 16100
647247 | Level 1 |  | Level: Level 1 | -473.013 | 2873.01 | 0.131234 | 420474 | 528 | -473.013 | 40 mmø | 1004 | 0.134167 | 0.158333 | 3346.03 | 0 | 16100
647252 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.164042 | 452702 | 529 | 2873.75 | 50 mmø | 1005 | 0.17225 | 0.197917 | 2881.99 | 0 | 20670
647348 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.164042 | 246206 | 530 | 2873.75 | 50 mmø | 1006 | 0.17225 | 0.197917 | 1567.4 | 0 | 20670
647409 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.164042 | 76893.8 | 531 | 2873.75 | 50 mmø | 1009 | 0.17225 | 0.197917 | 489.521 | 0 | 20670
647416 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.164042 | 811560 | 529 | 2873.75 | 50 mmø | 1010 | 0.17225 | 0.197917 | 5166.55 | 0 | 20670
647417 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.164042 | 59867.3 | 531 | 2873.75 | 50 mmø | 1011 | 0.17225 | 0.197917 | 381.127 | 0 | 20670
647642 | Level 1 | 0 | Level: Level 1 | 0 | 0 | 0.164042 | 52355.6 | 541 | -26.2509 | 50 mmø | 1020 | 0.17225 | 0.197917 | 333.306 | 0 | 20670
647669 | Level 1 | 0 | Level: Level 1 | 0 | 0 | 0.164042 | 29778.2 | 541 | -26.2509 | 50 mmø | 1021 | 0.17225 | 0.197917 | 189.574 | 0 | 20670
647751 | Level 1 | 0 | Level: Level 1 | 1000 | 1000 | 0.164042 | 62187.8 | 541 | 973.749 | 50 mmø | 1024 | 0.17225 | 0.197917 | 395.9 | 0 | 20670
647760 | Level 1 |  | Level: Level 1 | 33.3375 | 966.663 | 0.164042 | 146606 | 541 | 33.3375 | 50 mmø | 1025 | 0.17225 | 0.197917 | 933.325 | 0 | 20670
647781 | Level 1 |  | Level: Level 1 | 1039.69 | 2866.66 | 0.164042 | 286981 | 531 | 1039.69 | 50 mmø | 1026 | 0.17225 | 0.197917 | 1826.98 | 0 | 20670
647787 | Level 1 |  | Level: Level 1 | 324.214 | 960.312 | 0.164042 | 99918.2 | 539 | 324.214 | 50 mmø | 1027 | 0.17225 | 0.197917 | 636.099 | 0 | 20670
647812 | Level 1 | 0 | Level: Level 1 | 0 | 0 | 0.131234 | 25117.8 | 47 | -20.447 | 40 mmø | 1028 | 0.134167 | 0.158333 | 199.881 | 1 | 16100
647819 | Level 1 |  | Level: Level 1 | 713 | 23.8125 | 0.104987 | 69284.7 | 46 | 23.8125 | 32 mmø | 1029 | 0.115 | 0.138333 | 689.188 | 1 | 13800
647822 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.131234 | 12066.9 | 47 | 2879.55 | 40 mmø | 1030 | 0.134167 | 0.158333 | 96.025 | 1 | 16100
647886 | Level 1 |  | Level: Level 1 | 26.9875 | 2873.01 | 0.131234 | 357642 | 47 | 26.9875 | 40 mmø | 1031 | 0.134167 | 0.158333 | 2846.03 | 1 | 16100
647890 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.131234 | 269677 | 47 | 2879.55 | 40 mmø | 1032 | 0.134167 | 0.158333 | 2146.03 | 1 | 16100
647946 | Level 1 |  | Level: Level 1 | 2926.99 | 4870 | 0.131234 | 244166 | 47 | 2926.99 | 40 mmø | 1034 | 0.134167 | 0.158333 | 1943.01 | 1 | 16100
648020 | Level 1 | 0 | Level: Level 1 | 0 | 0 | 0.131234 | 28492.7 | 542 | -20.447 | 40 mmø | 1035 | 0.134167 | 0.158333 | 226.738 | 0 | 16100
648112 | Level 1 |  | Level: Level 1 | 26.9875 | 4870 | 0.131234 | 608591 | 542 | 26.9875 | 40 mmø | 1039 | 0.134167 | 0.158333 | 4843.01 | 0 | 16100
648138 | Level 1 | 0 | Level: Level 1 | 2900 | 2900 | 0.328084 | 440616 | 544 | 2848.87 | 100 mmø | 1040 | 0.3355 | 0.375 | 1402.53 | 0 | 40260
648145 | Level 1 |  | Level: Level 1 | 65.0875 | 2841.26 | 0.328084 | 872161 | 544 | 65.0875 | 100 mmø | 1041 | 0.3355 | 0.375 | 2776.18 | 0 | 40260
648198 | Level 1 |  | Level: Level 1 | 2958.74 | 4870 | 0.328084 | 600441 | 544 | 2958.74 | 100 mmø | 1044 | 0.3355 | 0.375 | 1911.26 | 0 | 40260
648213 | Level 1 | 0 | Level: Level 1 | 0 | 0 | 0.104987 | 16640.8 | 547 | -17.526 | 32 mmø | 1045 | 0.115 | 0.138333 | 165.529 | 0 | 13800
648316 | Level 1 |  | Level: Level 1 | 23.8125 | 4870 | 0.104987 | 487192 | 547 | 23.8125 | 32 mmø | 1048 | 0.115 | 0.138333 | 4846.19 | 0 | 13800
648381 | Level 1 | 0 | Level: Level 1 | 0 | 0 | 0.104987 | 21717.2 | 548 | -17.526 | 32 mmø | 1049 | 0.115 | 0.138333 | 216.025 | 0 | 13800
648419 | Level 1 | 0 | Level: Level 1 | 2800 | 2800 | 0.104987 | 103786 | 548 | 2782.47 | 32 mmø | 1051 | 0.115 | 0.138333 | 1032.38 | 0 | 13800
648432 | Level 1 |  | Level: Level 1 | 23.8125 | 2776.19 | 0.104987 | 276699 | 548 | 23.8125 | 32 mmø | 1052 | 0.115 | 0.138333 | 2752.38 | 0 | 13800
653707 | Level 2 | 0 | Level: Level 2 | -411 | -411 | 0.104987 | 84287 | 212 | 4141.47 | 32 mmø | 1060 | 0.115 | 0.138333 | 838.418 | 2 | 13800
653737 | Level 2 | 0 | Level: Level 2 | -411 | -411 | 0.262467 | 1136669 | 560 | 4120.04 | 80 mmø | 1063 | 0.255667 | 0.291667 | 4522.66 | 0 | 30680
653820 | Level 2 | 0 | Level: Level 2 | -411 | -411 | 0.104987 | 26901 | 212 | 4141.47 | 32 mmø | 1065 | 0.115 | 0.138333 | 267.589 | 2 | 13800
654912 | Level 2 | 0 | Level: Level 2 | -200 | -200 | 0.164042 | 16406.4 | 585 | 4343.75 | 50 mmø | 1102 | 0.17225 | 0.197917 | 104.446 | 0 | 20670
654918 | Level 2 | 0 | Level: Level 2 | -200 | -200 | 0.164042 | 10455.4 | 577 | 4343.75 | 50 mmø | 1103 | 0.17225 | 0.197917 | 66.5609 | 0 | 20670
654981 | Level 2 | 0 | Level: Level 2 | -200 | -200 | 0.164042 | 51219.1 | 585 | 4343.75 | 50 mmø | 1104 | 0.17225 | 0.197917 | 326.071 | 0 | 20670
655486 | Level 2 | 0 | Level: Level 2 | -200 | -200 | 0.131234 | 11193.2 | 576 | 4349.55 | 40 mmø | 1125 | 0.134167 | 0.158333 | 89.0729 | 0 | 16100
655493 | Level 2 |  | Level: Level 2 | -319.719 | -226.987 | 0.131234 | 11653 | 576 | 4250.28 | 40 mmø | 1126 | 0.134167 | 0.158333 | 92.7313 | 0 | 16100
655502 | Level 2 | 0 | Level: Level 2 | -200 | -200 | 0.164042 | 96393.4 | 574 | 4343.75 | 50 mmø | 1128 | 0.17225 | 0.197917 | 613.659 | 0 | 20670
655509 | Level 2 | 0 | Level: Level 2 | -200 | -200 | 0.131234 | 16805.2 | 579 | 4349.55 | 40 mmø | 1129 | 0.134167 | 0.158333 | 133.731 | 0 | 16100
655521 | Level 2 | 0 | Level: Level 2 | -200 | -200 | 0.164042 | 35619.1 | 577 | 4343.75 | 50 mmø | 1131 | 0.17225 | 0.197917 | 226.758 | 0 | 20670
655593 | Level 2 | 0 | Level: Level 2 | -200 | -200 | 0.131234 | 7226.97 | 584 | 4349.55 | 40 mmø | 1133 | 0.134167 | 0.158333 | 57.5104 | 0 | 16100
655598 | Level 2 |  | Level: Level 2 | -319.719 | -226.987 | 0.131234 | 11653 | 584 | 4250.28 | 40 mmø | 1134 | 0.134167 | 0.158333 | 92.7312 | 0 | 16100
655607 | Level 2 | 0 | Level: Level 2 | -200 | -200 | 0.164042 | 75583.2 | 586 | 4343.75 | 50 mmø | 1136 | 0.17225 | 0.197917 | 481.178 | 0 | 20670
656298 | Level 1 |  | Level: Level 1 | 452.387 | 2856.34 | 0.262467 | 604180 | 598 | 452.387 | 80 mmø | 1158 | 0.255667 | 0.291667 | 2403.96 | 0 | 30680
656799 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.131234 | 229961 | 602 | -320.447 | 40 mmø | 1176 | 0.134167 | 0.158333 | 1829.97 | 0 | 16100
657129 | Level 2 |  | Level: Level 2 | -1509.69 | -1609.97 | 0.164042 | 15752.1 | 608 | 2960.03 | 50 mmø | 1188 | 0.17225 | 0.197917 | 100.281 | 0 | 20670
657131 | Level 1 | 0 | Level: Level 1 | 3100 | 3100 | 0.164042 | 21744.2 | 610 | 3073.75 | 50 mmø | 1189 | 0.17225 | 0.197917 | 138.428 | 0 | 20670
657217 | Level 1 | 0 | Level: Level 1 | 3100 | 3100 | 0.164042 | 48337.6 | 609 | 3073.75 | 50 mmø | 1192 | 0.17225 | 0.197917 | 307.727 | 0 | 20670
657583 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.164042 | 77491.3 | 461 | -326.251 | 50 mmø | 1197 | 0.17225 | 0.197917 | 493.325 | 0 | 20670
657669 | Level 1 |  | Level: Level 1 | -266.663 | 3136.66 | 0.164042 | 534593 | 461 | -266.663 | 50 mmø | 1199 | 0.17225 | 0.197917 | 3403.33 | 0 | 20670
657936 | Level 2 |  | Level: Level 2 | -1596.92 | -1439.69 | 0.164042 | 24697.8 | 616 | 2973.08 | 50 mmø | 1206 | 0.17225 | 0.197917 | 157.231 | 0 | 20670
657990 | Level 2 | 0 | Level: Level 2 | -1400 | -1400 | 0.164042 | 79846.3 | 461 | 3143.75 | 50 mmø | 1208 | 0.17225 | 0.197917 | 508.317 | 0 | 20670
657997 | Level 2 | 0 | Level: Level 2 | -1400 | -1400 | 0.164042 | 87184 | 615 | 3143.75 | 50 mmø | 1210 | 0.17225 | 0.197917 | 555.03 | 0 | 20670
658316 | Level 2 | 0 | Level: Level 2 | -1400 | -1400 | 0.164042 | 17801 | 624 | 3143.75 | 50 mmø | 1225 | 0.17225 | 0.197917 | 113.325 | 0 | 20670
658323 | Level 2 |  | Level: Level 2 | -1596.92 | -1433.34 | 0.164042 | 25695.3 | 624 | 2973.08 | 50 mmø | 1226 | 0.17225 | 0.197917 | 163.581 | 0 | 20670
658466 | Level 2 | 0 | Level: Level 2 | -1400 | -1400 | 0.164042 | 15662 | 628 | 3143.75 | 50 mmø | 1235 | 0.17225 | 0.197917 | 99.7073 | 0 | 20670
658519 | Level 1 | 0 | Level: Level 1 | 600 | 600 | 0.164042 | 35688.1 | 627 | 573.749 | 50 mmø | 1239 | 0.17225 | 0.197917 | 227.197 | 0 | 20670
658565 | Level 2 |  | Level: Level 2 | -1596.92 | -1439.69 | 0.164042 | 24697.8 | 633 | 2973.08 | 50 mmø | 1242 | 0.17225 | 0.197917 | 157.231 | 0 | 20670
659099 | Level 2 | 0 | Level: Level 2 | -1400 | -1400 | 0.131234 | 10972 | 638 | 3149.55 | 40 mmø | 1268 | 0.134167 | 0.158333 | 87.3126 | 0 | 16100
659106 | Level 2 |  | Level: Level 2 | -1661.21 | -1426.99 | 0.131234 | 29433.6 | 638 | 2908.79 | 40 mmø | 1269 | 0.134167 | 0.158333 | 234.225 | 0 | 16100
661047 | Level 2 |  | Level: Level 2 | 239.687 | 466.663 | 0.164042 | 35653.1 | 681 | 4809.69 | 50 mmø | 1355 | 0.17225 | 0.197917 | 226.975 | 0 | 20670
661104 | Level 2 | 0 | Level: Level 2 | 500 | 500 | 0.164042 | 15767.7 | 681 | 5043.75 | 50 mmø | 1359 | 0.17225 | 0.197917 | 100.38 | 0 | 20670
661115 | Level 2 | 0 | Level: Level 2 | 500 | 500 | 0.164042 | 61590.5 | 681 | 5043.75 | 50 mmø | 1361 | 0.17225 | 0.197917 | 392.097 | 0 | 20670
661126 | Level 2 | 0 | Level: Level 2 | 500 | 500 | 0.164042 | 53072.5 | 681 | 5043.75 | 50 mmø | 1362 | 0.17225 | 0.197917 | 337.87 | 0 | 20670
662680 | Level 2 | 0 | Level: Level 2 | 500 | 500 | 0.164042 | 51361.1 | 728 | 5043.75 | 50 mmø | 1460 | 0.17225 | 0.197917 | 326.975 | 0 | 20670
662850 | Level 1 |  | Level: Level 1 | -446.819 | -330.163 | 0.104987 | 11727.6 | 708 | -446.819 | 32 mmø | 1463 | 0.115 | 0.138333 | 116.656 | 0 | 13800
664253 | Level 2 | 0 | Level: Level 2 | -1400 | -1400 | 0.131234 | 45335.7 | 740 | 3149.55 | 40 mmø | 1488 | 0.134167 | 0.158333 | 360.77 | 0 | 16100
664263 | Level 1 |  | Level: Level 1 | -266.662 | 3136.66 | 0.131234 | 427674 | 519 | -266.663 | 40 mmø | 1489 | 0.134167 | 0.158333 | 3403.33 | 0 | 16100
664264 | Level 2 | 0 | Level: Level 2 | -1400 | -1400 | 0.131234 | 123365 | 740 | 3149.55 | 40 mmø | 1490 | 0.134167 | 0.158333 | 981.71 | 0 | 16100
664298 | Level 2 | 0 | Level: Level 2 | -1400 | -1400 | 0.131234 | 56207.8 | 740 | 3149.55 | 40 mmø | 1491 | 0.134167 | 0.158333 | 447.287 | 0 | 16100
664312 | Level 2 |  | Level: Level 2 | -1615.97 | -1426.99 | 0.131234 | 23748.1 | 740 | 2954.03 | 40 mmø | 1492 | 0.134167 | 0.158333 | 188.981 | 0 | 16100
664515 | Level 2 | 0 | Level: Level 2 | 500 | 500 | 0.131234 | 20916.7 | 751 | 5049.55 | 40 mmø | 1502 | 0.134167 | 0.158333 | 166.45 | 0 | 16100
664526 | Level 2 |  | Level: Level 2 | 239.688 | 460.312 | 0.164042 | 34655.7 | 749 | 4809.69 | 50 mmø | 1503 | 0.17225 | 0.197917 | 220.625 | 0 | 20670
683383 | Level 1 | 0 | Level: Level 1 | -300 | -300 | 0.164042 | 37911.8 | 810 | -326.251 | 50 mmø | 1845 | 0.17225 | 0.197917 | 241.354 | 0 | 20670
683396 | Level 1 |  | Level: Level 1 | -408.719 | -333.337 | 0.164042 | 11840.9 | 810 | -408.719 | 50 mmø | 1846 | 0.17225 | 0.197917 | 75.3812 | 0 | 20670
703588 | Level 1 |  | Level: Level 1 | -446.819 | -326.988 | 0.131234 | 15058.4 | 834 | -446.819 | 40 mmø | 2803 | 0.134167 | 0.158333 | 119.831 | 0 | 16100
997956 | Level 2 | 0 | Level: Level 2 | 200 | 200 | 0.164042 | 71056.7 | 839 | 4743.75 | 50 mmø | 3668 | 0.17225 | 0.197917 | 452.361 | 0 | 20670
998830 | Level 2 | 0 | Level: Level 2 | -1570 | -1570 | 0.131234 | 143983 | 468 | 2979.55 | 40 mmø | 3676 | 0.134167 | 0.158333 | 1145.78 | 0 | 16100
1098596 | Level 2 |  | Level: Level 2 | 0 | -376.869 | 0.131234 | 47358.7 | 211 | 4193.13 | 40 mmø | 5421 | 0.134167 | 0.158333 | 376.869 | 2 | 16100
1127642 | Level 1 |  | Level: Level 1 | 3533.01 | 2926.99 | 0.131234 | 76155.3 | 751 | 2926.99 | 40 mmø | 5585 | 0.134167 | 0.158333 | 606.025 | 0 | 16100
1127653 | Level 1 |  | Level: Level 1 | 3763.71 | 3586.99 | 0.131234 | 22207.9 | 751 | 3586.99 | 40 mmø | 5586 | 0.134167 | 0.158333 | 176.725 | 0 | 16100

# IfcFlowSegment: Pipe Types:Waste:577155 (822)
Type - ElementType: Pipe Types:Waste:577155
Mechanical - Material: Plastic; Schedule/Type: Pipe Schedule Types: Schedule 40; Connection Type: Generic; System Type: Piping System: Sanitary 1; Pipe Segment: Plastic - Schedule 40; Roughness: 0.00000833333; System Name: Sanitary 1; System Classification: Sanitary
Constraints - Horizontal Justification: 0; Vertical Justification: 0
Text - Gradient: 0; InvertElevation: 1; OuterDiameter: 1; NominalDiameter: 1; InnerDiameter: 1; WorkingPressure: 0; TemperatureRange: 0; LeakageCurve: 0; PressureRange: 0; InteriorRoughnessCoefficient: 0; FluidFlowLeakage: 0
