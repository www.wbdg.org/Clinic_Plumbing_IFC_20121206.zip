Properties of the parts of a building model (IFC2X3), part 19 of 29

# IfcFlowSegment: Pipe Types:Cold Water:677372 (822)
Name (Pipe Types:Cold Water:...) | In | Friction Factor | Reynolds Number | Flow State | Pressure Drop | Velocity | Flow | Fixture Units | Relative Roughness | Friction | Mark | Area (mm2) | Schedule/Type | Roughness | Material | Pipe Segment | Diameter | Section | Invert Elevation (mm) | System Name | End Offset (mm) | Start Offset (mm) = Offset (mm) | Reference Level | Slope | Outer Diameter | Size = Overall Size | Inner Diameter | Length (mm)
684849 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1926 | 74558.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 379 | -495.216 | Domestic Cold Water 1 | 691.419 | -495.216 | Level: Level 1 |  | 0.0625 | 20 mmø | 0.0531824 | 1186.63
684875 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1929 | 7444.27 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 380 | 705.933 | Domestic Cold Water 1 | 711.263 | 711.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 157.972
684894 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1932 | 6585.38 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 381 | 763.254 | Domestic Cold Water 1 | 768.584 | 768.584 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 139.746
684939 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1933 | 47042 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 377 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 748.697
684963 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1934 | 153021 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 388 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 3247.2
684970 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1935 | 348245 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 353 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 4434
684974 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1936 | 49547.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 388 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1051.43
685033 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1938 | 56330.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 388 | -498.391 | Domestic Cold Water 1 | 696.975 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 1195.37
685106 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1942 | 11879.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 386 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 252.09
685164 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1943 | 384935 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 145 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 8168.58
685174 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 1944 | 1699137 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 351 | -561.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.333333 | 100 mmø | 0.320013 | 5408.52
685179 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1945 | 43450.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 145 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 922.054
685186 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1946 | 51667.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 145 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1096.43
685203 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1947 | 4437.55 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 145 | 194.67 | Domestic Cold Water 1 | 200 | 200 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 94.1677
685251 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1948 | 32237.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 145 | -498.391 | Domestic Cold Water 1 | 185.713 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 684.103
685257 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1949 | 27517.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 145 | 214.287 | Domestic Cold Water 1 | 798.223 | 214.287 | Level: Level 1 | 5719.05 | 0.0416667 | 15 mmø | 0.0349738 | 583.936
685403 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1950 | 35855.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 147 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 760.868
685450 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1951 | 10229.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 217 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 81.404
685455 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 1952 | 2906958 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 389 | -561.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.333333 | 100 mmø | 0.320013 | 9253.14
685459 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1953 | 105517 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 112 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 839.675
685512 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1955 | 151720 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 112 | -485.691 | Domestic Cold Water 1 | 721.656 | -485.691 | Level: Level 1 |  | 0.125 | 40 mmø | 0.114304 | 1207.35
685544 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1956 | 1774.19 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 111 | 760.562 | Domestic Cold Water 1 | 798.223 | 760.574 | Level: Level 1 | 455.764 | 0.0416667 | 15 mmø | 0.0349738 | 37.6495
685545 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1957 | 4900.11 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 111 | 740.933 | Domestic Cold Water 1 | 746.263 | 746.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 103.984
685549 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1958 | 2604.44 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 111 | 740.933 | Domestic Cold Water 1 | 746.263 | 746.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 55.2679
685585 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1959 | 3538.81 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 392 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 28.1609
685625 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 1960 | 36682.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 447 | -561.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.333333 | 100 mmø | 0.320013 | 116.764
685634 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 1961 | 380545 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 390 | -561.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.333333 | 100 mmø | 0.320013 | 1211.31
685636 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 1962 | 49516.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 411 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 242.485
685673 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 1963 | 61218.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 400 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 299.793
685685 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 1964 | 385131 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 398 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 2451.82
685695 | Level 1 | 0.0106702 | 52695.1 | 2 | 137.101 | 4.08138 | 0.0779803 | 20 | 18716.5 | 16.117 | 1965 | 407279 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 23 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 2592.82
685744 | Level 1 | 0.0106702 | 52695.1 | 2 | 59.6401 | 4.08138 | 0.0779803 | 20 | 18716.5 | 16.117 | 1967 | 177170 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 23 | -479.341 | Domestic Cold Water 1 | 648.556 | -479.341 | Level: Level 1 |  | 0.166667 | 50 mmø | 0.155971 | 1127.9
685771 | Level 1 | 0.0122545 | 85661.5 | 2 | 381.441 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 1968 | 19949.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 24 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 254.005
685863 | Level 1 | 0.0122545 | 85661.5 | 2 | 558.998 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 1971 | 29235.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 24 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 372.242
685874 | Level 1 | 0.0122545 | 85661.5 | 2 | 381.441 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 1972 | 19949.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 21 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 254.005
685881 | Level 1 | 0.0122545 | 85661.5 | 2 | 871.168 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 1974 | 45562.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 21 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 580.12
685906 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 1975 | 86800.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 398 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 552.59
685950 | Level 1 | 0.0106702 | 52695.1 | 2 | 49.5872 | 4.08138 | 0.0779803 | 20 | 18716.5 | 16.117 | 1976 | 147306 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 29 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 937.779
685957 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 1977 | 411360 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 397 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 2618.8
685959 | Level 1 | 0.0112912 | 71903.6 | 2 | 513.374 | 7.59922 | 0.0779803 | 20 | 13716.5 | 80.6779 | 1978 | 243727 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 28 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 1939.52
686017 | Level 1 | 0.0112912 | 71903.6 | 2 | 302.536 | 7.59922 | 0.0779803 | 20 | 13716.5 | 80.6779 | 1980 | 143631 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 28 | -485.691 | Domestic Cold Water 1 | 657.288 | -485.691 | Level: Level 1 |  | 0.125 | 40 mmø | 0.114304 | 1142.98
686044 | Level 1 | 0.0122545 | 85661.5 | 2 | 371.905 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 1981 | 19450.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 26 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 247.655
686045 | Level 1 | 0.0122545 | 85661.5 | 2 | 620.627 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 1982 | 32459.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 31 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 413.282
686121 | Level 1 | 0.0122545 | 111043 | 2 | 735.502 | 18.1237 | 0.0779803 | 20 | 8881.89 | 769.144 | 1984 | 22891.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 27 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 291.468
686138 | Level 1 | 0.0122545 | 85661.5 | 2 | 929.141 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 1985 | 48594.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 31 | 676.921 | Domestic Cold Water 1 | 688.201 | 688.244 | Level: Level 1 | 0.0000684768 | 0.0833333 | 25 mmø | 0.0740157 | 618.725
686145 | Level 1 | 0.0122545 | 85661.5 | 2 | 897.745 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 1986 | 46952.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 31 | 676.92 | Domestic Cold Water 1 | 688.2 | 688.2 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 597.818
686246 | Level 1 | 0.0122545 | 85661.5 | 2 | 400.288 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 1988 | 20935.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 31 | 708.837 | Domestic Cold Water 1 | 975.394 | 708.837 | Level: Level 1 |  | 0.0833333 | 25 mmø | 0.0740157 | 266.556
686345 | Level 1 | 0.0130723 | 119218 | 2 | 2030.46 | 27.0804 | 0.0601563 | 10 | 6381.89 | 2549.38 | 1989 | 15253 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 30 | 991.895 | Domestic Cold Water 1 | 1000 | 1000 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 242.758
686354 | Level 1 | 0.0130723 | 119218 | 2 | 612.566 | 27.0804 | 0.0601563 | 10 | 6381.89 | 2549.38 | 1990 | 4601.65 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 30 | 909.3 | Domestic Cold Water 1 | 982.538 | 909.3 | Level: Level 1 |  | 0.0625 | 20 mmø | 0.0531824 | 73.2375
686384 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1991 | 76379.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 93 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1620.82
686391 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 1992 | 139259 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 399 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 886.552
686395 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1993 | 32582.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 93 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 691.425
686442 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1995 | 40308.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 93 | -498.391 | Domestic Cold Water 1 | 356.975 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 855.366
686468 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1996 | 19446.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 93 | 385.551 | Domestic Cold Water 1 | 798.223 | 385.553 | Level: Level 1 | 3162.02 | 0.0416667 | 15 mmø | 0.0349738 | 412.67
686469 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1997 | 2655.24 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 93 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 56.3459
686479 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 1998 | 50046.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 399 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 318.607
686493 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 1999 | 1582.77 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 404 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 10.0762
686498 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 2000 | 633647 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 411 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 3103.01
686502 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2001 | 689205 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 403 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 10969
686521 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2002 | 43741.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 403 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 696.166
686528 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2003 | 22933.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 403 | 491.895 | Domestic Cold Water 1 | 500 | 500 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 364.992
686550 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2004 | 61434 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 403 | -495.216 | Domestic Cold Water 1 | 482.538 | -495.216 | Level: Level 1 |  | 0.0625 | 20 mmø | 0.0531824 | 977.753
686584 | Level 1 | 0.0106702 | 22583.6 | 2 | 24.1508 | 1.74916 | 0.0334201 | 2.25 | 18716.5 | 2.96026 | 2005 | 390604 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 80 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 2486.66
686591 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2006 | 480974 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 406 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 3061.97
686592 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2007 | 45077.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 105 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 286.975
686636 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2009 | 129249 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 105 | -479.341 | Domestic Cold Water 1 | 343.481 | -479.341 | Level: Level 1 |  | 0.166667 | 50 mmø | 0.155971 | 822.822
686662 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2010 | 19446.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 104 | 385.549 | Domestic Cold Water 1 | 798.223 | 385.55 | Level: Level 1 | 4100.48 | 0.0416667 | 15 mmø | 0.0349738 | 412.673
686663 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2011 | 6993.38 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 104 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 148.404
686666 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2012 | 2946.02 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 104 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 62.5165
686693 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2013 | 43002.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 405 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 273.761
686714 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2014 | 177304 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 410 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 1410.94
686721 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 2015 | 711020 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 402 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 4526.49
686725 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2016 | 146084 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 410 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 1162.5
686773 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2018 | 143332 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 410 | -485.691 | Domestic Cold Water 1 | 654.906 | -485.691 | Level: Level 1 |  | 0.125 | 40 mmø | 0.114304 | 1140.6
686796 | Level 1 | 0.0122545 | 85661.5 | 2 | 20.0665 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 2019 | 1049.49 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 32 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 13.3625
686831 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2021 | 70049.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 408 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 557.434
686865 | Level 1 | 0.0142324 | 100715 | 2 | 75169.9 | 34.7884 | 0.0334201 | 0.5 | 4196.85 | 6965.4 | 2022 | 155008 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 56 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 3289.37
686872 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 2023 | 496371 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 412 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 2430.77
686876 | Level 1 | 0.0142324 | 100715 | 2 | 86548 | 34.7884 | 0.0334201 | 0.5 | 4196.85 | 6965.4 | 2024 | 178471 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 56 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 3787.27
686919 | Level 1 | 0.0142324 | 100715 | 2 | 31684.2 | 34.7884 | 0.0334201 | 0.5 | 4196.85 | 6965.4 | 2026 | 65336 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 56 | -498.391 | Domestic Cold Water 1 | 888.081 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 1386.47
686946 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2027 | 126663 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 96 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 2687.87
686953 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 2028 | 225568 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 413 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 1104.62
686957 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2029 | 66511.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 96 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1411.43
687003 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2031 | 58215.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 96 | -498.391 | Domestic Cold Water 1 | 736.975 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 1235.37
687033 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2032 | 1538.45 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 96 | 765.564 | Domestic Cold Water 1 | 798.223 | 765.577 | Level: Level 1 | 425.124 | 0.0416667 | 15 mmø | 0.0349738 | 32.647
687034 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2033 | 4857.94 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 96 | 745.933 | Domestic Cold Water 1 | 751.263 | 751.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 103.089
687037 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2034 | 3246.88 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 96 | 745.933 | Domestic Cold Water 1 | 751.263 | 751.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 68.9009
687072 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2035 | 11788.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 98 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 250.151
687173 | Level 1 | 0.0142324 | 100715 | 2 | 17414 | 34.7884 | 0.0334201 | 0.5 | 4196.85 | 6965.4 | 2036 | 35909.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 58 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 762.021
687189 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2037 | 22063.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 417 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 280.924
687196 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 2038 | 159288 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 433 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 780.044
687200 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2039 | 136660 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 417 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 1740
687205 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2040 | 73727.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 417 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 938.725
687214 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2041 | 9304.61 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 711 | 188.72 | Domestic Cold Water 1 | 200 | 200 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 118.47
687305 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2045 | 38196.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 142 | 594.67 | Domestic Cold Water 1 | 600 | 600 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 810.552
687332 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2048 | 27176.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 710 | 226.987 | Domestic Cold Water 1 | 573.012 | 226.987 | Level: Level 1 |  | 0.0833333 | 25 mmø | 0.0740157 | 346.025
687346 | Level 1 | 0.0122545 | 85661.5 | 2 | 210.229 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 2049 | 10995.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 14 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 139.994
687347 | Level 1 | 0.0122545 | 85661.5 | 2 | 376.258 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 2050 | 19678.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 14 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 250.554
687444 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2053 | 8667.48 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 142 | 614.29 | Domestic Cold Water 1 | 798.223 | 614.294 | Level: Level 1 | 1497.12 | 0.0416667 | 15 mmø | 0.0349738 | 183.93
687446 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2054 | 8018.12 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 142 | 594.67 | Domestic Cold Water 1 | 600 | 600 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 170.15
687648 | Level 1 | 0.0122545 | 85661.5 | 2 | 60.9974 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 2056 | 3190.19 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 14 | 626.987 | Domestic Cold Water 1 | 626.987 | 667.606 | Level: Level 1 |  | 0.0833333 | 25 mmø | 0.0740157 | 40.6188
687728 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2059 | 30689 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 415 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 390.745
687752 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2060 | 142606 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 421 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 2269.64
687759 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 2061 | 681155 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 424 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 3335.67
687763 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2062 | 60478 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 421 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 962.538
687796 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2063 | 57725.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 91 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 918.725
687801 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2064 | 36024.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 423 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 573.35
687833 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2066 | 72359.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 91 | -495.216 | Domestic Cold Water 1 | 656.419 | -495.216 | Level: Level 1 |  | 0.0625 | 20 mmø | 0.0531824 | 1151.63
687863 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2068 | 3188.83 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 90 | 670.933 | Domestic Cold Water 1 | 676.263 | 676.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 67.6691
687892 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2069 | 12832.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 420 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 204.229
687906 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2070 | 49242.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 428 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 783.722
687913 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 2071 | 223634 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 438 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 1095.15
687917 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2072 | 43020.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 428 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 684.696
687942 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2074 | 75658 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 428 | -495.216 | Domestic Cold Water 1 | 708.919 | -495.216 | Level: Level 1 |  | 0.0625 | 20 mmø | 0.0531824 | 1204.13
687976 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2077 | 12214.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 427 | 723.433 | Domestic Cold Water 1 | 728.763 | 728.763 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 259.194
687990 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2078 | 42621.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 429 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 678.346
687995 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2079 | 185532 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 432 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 2952.83
688023 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2081 | 75436.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 429 | -495.216 | Domestic Cold Water 1 | 705.387 | -495.216 | Level: Level 1 |  | 0.0625 | 20 mmø | 0.0531824 | 1200.6
688074 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2083 | 4617.96 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 430 | 719.901 | Domestic Cold Water 1 | 725.231 | 725.231 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 97.9961
688077 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2084 | 14394.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 430 | 719.901 | Domestic Cold Water 1 | 725.231 | 725.231 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 305.453
688108 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2085 | 24546.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 426 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 390.665
688122 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2086 | 78009.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 437 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1655.42
688129 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 2087 | 247345 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 418 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 1211.27
688133 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2088 | 110121 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 437 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 2336.84
688140 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2089 | 25042.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 437 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 531.425
688149 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2090 | 2625.39 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 437 | 194.67 | Domestic Cold Water 1 | 200 | 200 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 55.7125
688173 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2091 | 32237.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 437 | -498.391 | Domestic Cold Water 1 | 185.713 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 684.103
688239 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2092 | 34994.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 435 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 742.6
688255 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2093 | 48928.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 441 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 778.725
688262 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 2094 | 7597.42 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 396 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 37.2051
688266 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2095 | 45557.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 441 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 725.075
688333 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2097 | 76757.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 441 | -495.216 | Domestic Cold Water 1 | 726.419 | -495.216 | Level: Level 1 |  | 0.0625 | 20 mmø | 0.0531824 | 1221.63
688348 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2098 | 45158.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 442 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 718.725
688353 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2099 | 189392 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 446 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 3014.27
688382 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2101 | 78014.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 442 | -495.216 | Domestic Cold Water 1 | 746.419 | -495.216 | Level: Level 1 |  | 0.0625 | 20 mmø | 0.0531824 | 1241.63
688415 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2104 | 13830.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 443 | 740.933 | Domestic Cold Water 1 | 746.263 | 746.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 293.491
688434 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2107 | 11604.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 444 | 760.933 | Domestic Cold Water 1 | 766.263 | 766.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 246.253
688481 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2108 | 56185.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 440 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 894.22
688514 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 28401.6 | 0 | 2109 | 415084 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.262467 | 449 | -548.748 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.25 | 80 mmø | 0.23668 | 1651.57
688521 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 2110 | 1475476 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 450 | -561.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.333333 | 100 mmø | 0.320013 | 4696.59
688525 | Level 2 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 28401.6 | 0 | 2111 | 58687.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.262467 | 449 | 3033.93 | Domestic Cold Water 1 | -1500 | -1500 | Level: Level 2 | 0 | 0.25 | 80 mmø | 0.23668 | 233.51
688557 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 28401.6 | 0 | 2112 | 877284 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.262467 | 449 | -466.641 | Domestic Cold Water 1 | 3023.96 | -466.641 | Level: Level 1 |  | 0.25 | 80 mmø | 0.23668 | 3490.6
688605 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 28401.6 | 0 | 2113 | 223208 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.262467 | 449 | -548.748 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.25 | 80 mmø | 0.23668 | 888.114
688643 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2114 | 49312.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 453 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 784.84
688653 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 2115 | 81072.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 459 | -561.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.333333 | 100 mmø | 0.320013 | 258.061
688658 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2116 | 42787.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 453 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 680.986
688663 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2117 | 45687.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 454 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 727.136
688668 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2118 | 186754 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 458 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 2972.28
688695 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2120 | 78328.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 454 | -495.216 | Domestic Cold Water 1 | 751.419 | -495.216 | Level: Level 1 |  | 0.0625 | 20 mmø | 0.0531824 | 1246.63
688706 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2122 | 78328.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 453 | -495.216 | Domestic Cold Water 1 | 751.419 | -495.216 | Level: Level 1 |  | 0.0625 | 20 mmø | 0.0531824 | 1246.63
688727 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2125 | 15643.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 455 | 765.933 | Domestic Cold Water 1 | 771.263 | 771.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 331.968
688749 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2127 | 9856.62 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 456 | 765.933 | Domestic Cold Water 1 | 771.263 | 771.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 209.164
688826 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2128 | 21458.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 452 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 341.522
688847 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2129 | 110527 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 85 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 2345.45
688854 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 2130 | 627145 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 460 | -561.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.333333 | 100 mmø | 0.320013 | 1996.27
688858 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2131 | 44843.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 85 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 951.601
688917 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2133 | 56801.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 85 | -498.391 | Domestic Cold Water 1 | 706.975 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 1205.37
688958 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2134 | 2953.41 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 85 | 735.55 | Domestic Cold Water 1 | 798.223 | 735.55 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 62.6734
688959 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2135 | 3276.29 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 85 | 715.933 | Domestic Cold Water 1 | 721.263 | 721.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 69.525
688962 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2136 | 15211.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 85 | 715.933 | Domestic Cold Water 1 | 721.263 | 721.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 322.801
688997 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2137 | 40714.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 87 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 863.994
689014 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2138 | 172655 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 464 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 1373.95
689021 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 2139 | 785058 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 395 | -561.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.333333 | 100 mmø | 0.320013 | 2498.92
689025 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2140 | 151554 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 464 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 1206.03
689098 | Level 1 | 0.0122545 | 85661.5 | 2 | 233.707 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 2143 | 12223 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 15 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 155.628
689099 | Level 1 | 0.0122545 | 85661.5 | 2 | 384.862 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 2144 | 20128.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 15 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 256.284
689121 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2145 | 8754.96 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 82 | 494.67 | Domestic Cold Water 1 | 500 | 500 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 185.786
689134 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2146 | 13380 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 82 | 514.289 | Domestic Cold Water 1 | 798.223 | 514.292 | Level: Level 1 | 2224.37 | 0.0416667 | 15 mmø | 0.0349738 | 283.932
689137 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2147 | 37477.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 82 | 494.67 | Domestic Cold Water 1 | 500 | 500 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 795.297
689183 | Level 1 | 0.0112912 | 55468.5 | 2 | 19.5244 | 5.86225 | 0.0601563 | 10 | 13716.5 | 48.0116 | 2148 | 15576 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 16 | 533.337 | Domestic Cold Water 1 | 657.288 | 533.337 | Level: Level 1 |  | 0.125 | 40 mmø | 0.114304 | 123.95
689189 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2149 | 119676 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 464 | -485.691 | Domestic Cold Water 1 | 466.662 | -485.691 | Level: Level 1 |  | 0.125 | 40 mmø | 0.114304 | 952.353
689220 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2150 | 103395 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 462 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 822.795
689248 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2151 | 148836 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 469 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 1895.04
689253 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 2152 | 28891.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 394 | -561.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.333333 | 100 mmø | 0.320013 | 91.9659
689291 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2154 | 52731.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 469 | -492.041 | Domestic Cold Water 1 | 179.363 | -492.041 | Level: Level 1 |  | 0.0833333 | 25 mmø | 0.0740157 | 671.403
689345 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2155 | 8486.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 467 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 108.057
689375 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2156 | 676464 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 474 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 10766.3
689380 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 2157 | 2124616 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 465 | -561.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.333333 | 100 mmø | 0.320013 | 6762.86
689384 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2158 | 32991.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 474 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 525.075
689391 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2159 | 37248.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 474 | 491.895 | Domestic Cold Water 1 | 500 | 500 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 592.822
689427 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2160 | 61434 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 474 | -495.216 | Domestic Cold Water 1 | 482.538 | -495.216 | Level: Level 1 |  | 0.0625 | 20 mmø | 0.0531824 | 977.753
689458 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2161 | 46496 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 472 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 740.007
689542 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2162 | 335849 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 134 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 7126.95
689547 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2163 | 296542 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 338 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 2359.8
689551 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2164 | 149450 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 134 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 3171.43
689558 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2165 | 41507.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 134 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 880.819
689600 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2167 | 40308.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 134 | -498.391 | Domestic Cold Water 1 | 356.975 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 855.366
689627 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2168 | 19446.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 134 | 385.549 | Domestic Cold Water 1 | 798.223 | 385.55 | Level: Level 1 | 4100.92 | 0.0416667 | 15 mmø | 0.0349738 | 412.673
689628 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2169 | 2557.71 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 134 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 54.2762
689631 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2170 | 3321.62 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 134 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 70.487
689753 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2171 | 10844.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 136 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 230.122
689801 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 2172 | 7418.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 475 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 59.0377
689846 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 2174 | 400666 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 470 | -561.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.333333 | 100 mmø | 0.320013 | 1275.36
689866 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 2175 | 34172.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 486 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 435.095
689878 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2176 | 29259.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 122 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 465.68
689892 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2177 | 124066 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 121 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 2632.76
689921 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2178 | 65751.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 119 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1395.3
689964 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2180 | 40308.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 119 | -498.391 | Domestic Cold Water 1 | 356.975 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 855.366
689987 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2181 | 19446.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 119 | 385.546 | Domestic Cold Water 1 | 798.223 | 385.548 | Level: Level 1 | 4100.48 | 0.0416667 | 15 mmø | 0.0349738 | 412.676
689988 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2182 | 3581.59 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 119 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 76.0038
690002 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2183 | 12777.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 121 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 271.141
690016 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2184 | 93712.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 114 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1988.64
690023 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2185 | 149579 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 482 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 2380.63
690059 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2187 | 40308.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 114 | -498.391 | Domestic Cold Water 1 | 356.975 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 855.366
690086 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2188 | 19446.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 114 | 385.546 | Domestic Cold Water 1 | 798.223 | 385.547 | Level: Level 1 | 4100.48 | 0.0416667 | 15 mmø | 0.0349738 | 412.676
690087 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2189 | 6698.43 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 114 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 142.145
690127 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2190 | 10989.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 116 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 233.195
690159 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2191 | 37975.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 124 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 805.875
690166 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 2192 | 62278 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 483 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 991.185
690206 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2194 | 40308.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 124 | -498.391 | Domestic Cold Water 1 | 356.975 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 855.366
690236 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2195 | 19446.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 124 | 385.546 | Domestic Cold Water 1 | 798.223 | 385.548 | Level: Level 1 | 4100.48 | 0.0416667 | 15 mmø | 0.0349738 | 412.676
690237 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 2196 | 2129.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 124 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 45.1936
