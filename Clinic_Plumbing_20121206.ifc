Properties of the parts of a building model (IFC2X3), part 17 of 29

# IfcFlowFitting: Transition - Generic (1079)
Name (M_Transition - Generic:Transition - Generic:Transition - Generic:...) | In | Fitting Outside Radius 1 = Insulation Radius 1 | Width Offset | Visibility 3 | Visibility 1 | Max Fitting Outside Diameter 12 | Visibility 2 | Fitting Outside Radius 2 = Insulation Radius 2 | Height Offset | System Name | System Classification | System Type | Loss Method | Offset (mm) | Level | Host | Mark | Fitting Outside Diameter 2 | OffsetHeight | Length | Nominal Radius 1 | OffsetWidth | Nominal Radius 2 | Tick Size 2 | Tick Size 1 | Fitting Outside Diameter 1 | Size = Overall Size | Nominal Diameter 1 | Nominal Diameter 2
1125810 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 15394 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
1125942 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 15419 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
1125954 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1350 | Level: Level 2 | Level : Level 2 | 15420 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1126238 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1350 | Level: Level 2 | Level : Level 2 | 15454 | 0.0729167 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0328084 | 0.0291667 | 0.0708333 | 0.177083 | 50 mmø-20 mmø | 0.164042 | 0.0656168
1126525 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0677083 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1500 | Level: Level 2 | Level : Level 2 | 15478 | 0.135417 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0656168 | 0.0541667 | 0.0708333 | 0.177083 | 50 mmø-40 mmø | 0.164042 | 0.131234
1126629 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0364583 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 15499 | 0.0729167 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0328084 | 0.0291667 | 0.0375 | 0.09375 | 25 mmø-20 mmø | 0.082021 | 0.0656168
1127269 | Level 1 | 0.0572917 | 10 | yes | no | 0.21875 | no | 0.109375 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | -1550 | Level: Level 2 | Level : Level 2 | 15539 | 0.21875 | 0.0524934 | 0.0546875 | 0.0524934 | 0.0524934 | 0.106627 | 0.0875 | 0.0458333 | 0.114583 | 65 mmø-32 mmø | 0.104987 | 0.213255
1129174 | Level 1 | 0.0885417 | 10 | no | no | 0.177083 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 15610 | 0.0520833 | 0.082021 | 0.0442708 | 0.082021 | 0.082021 | 0.0246063 | 0.0208333 | 0.0708333 | 0.177083 | 50 mmø-15 mmø | 0.164042 | 0.0492126
1184577 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15865 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1184607 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Hot Water | Piping System: Domestic Hot Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15869 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1184770 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Hot Water | Piping System: Domestic Hot Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15881 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1184805 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15885 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1184880 | Level 1 | 0.0260417 | 9.99988 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15888 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.024484 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1184904 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Hot Water | Piping System: Domestic Hot Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15891 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1184969 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Hot Water | Piping System: Domestic Hot Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15894 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1184999 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15898 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1185085 | Level 1 | 0.0416667 | 10 | no | no | 0.0833333 | yes | 0.0260417 | 10 | Domestic Hot Water 24 | Domestic Hot Water | Piping System: Domestic Hot Water | 1 | 1812.18 | Level: TOF Footing | Level : TOF Footing | 15904 | 0.0520833 | 0.0364583 | 0.0208333 | 0.0364583 | 0.0364583 | 0.0246063 | 0.0208333 | 0.0333333 | 0.0833333 | 22 mmø-15 mmø | 0.0729167 | 0.0492126
1185216 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15908 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1185304 | Level 1 | 0.0260417 | 9.99988 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Hot Water | Piping System: Domestic Hot Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15911 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.024484 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1185327 | Level 1 | 0.0260417 | 10.0001 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15914 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0247286 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1185385 | Level 1 | 0.0260417 | 10.0001 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15917 | 0.0833333 | 0.0246062 | 0.0208333 | 0.0246063 | 0.0247286 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1185443 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Hot Water | Piping System: Domestic Hot Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15920 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1185597 | Level 1 | 0.0416667 | 10 | no | no | 0.0833333 | yes | 0.0260417 | 10 | Unit B Domestic Cold Water 25 | Domestic Cold Water | Piping System: Unit B Domestic Cold Water | 1 | 812.183 | Level: Level 1 | Level : Level 1 | 15922 | 0.0520833 | 0.0364583 | 0.0208333 | 0.0364583 | 0.0364583 | 0.0246063 | 0.0208333 | 0.0333333 | 0.0833333 | 22 mmø-15 mmø | 0.0729167 | 0.0492126
1185623 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Hot Water | Piping System: Domestic Hot Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15925 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1185745 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Hot Water | Piping System: Domestic Hot Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15928 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1185802 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15931 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1185856 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Hot Water | Piping System: Domestic Hot Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15934 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1185890 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15939 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1185973 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 9.99988 | Domestic Hot Water 1 | Domestic Hot Water | Piping System: Domestic Hot Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15943 | 0.0833333 | 0.024484 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1186002 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15948 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1186075 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15952 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1186098 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Hot Water | Piping System: Domestic Hot Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15955 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1186178 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 9.99988 | Domestic Hot Water 1 | Domestic Hot Water | Piping System: Domestic Hot Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15959 | 0.0833333 | 0.024484 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1186204 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 9.99988 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15964 | 0.0833333 | 0.024484 | 0.0208333 | 0.0246063 | 0.0246066 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1186241 | Level 1 | 0.0416667 | 10 | no | no | 0.0833333 | yes | 0.0260417 | 10 | Domestic Hot Water 33 | Domestic Hot Water | Piping System: Domestic Hot Water | 1 | 812.183 | Level: Level 1 | Level : Level 1 | 15965 | 0.0520833 | 0.0364583 | 0.0208333 | 0.0364583 | 0.0364583 | 0.0246063 | 0.0208333 | 0.0333333 | 0.0833333 | 22 mmø-15 mmø | 0.0729167 | 0.0492126
1186271 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Hot Water | Piping System: Domestic Hot Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15968 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1186307 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15971 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1186463 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15974 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1186618 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Hot Water | Piping System: Domestic Hot Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15977 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1186641 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15980 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1186696 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Hot Water | Piping System: Domestic Hot Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15985 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1187006 | Level 1 | 0.0416667 | 10 | no | no | 0.0833333 | yes | 0.0260417 | 10 | Domestic Cold Water 1 2 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 1812.18 | Level: TOF Footing | Level : TOF Footing | 15988 | 0.0520833 | 0.0364583 | 0.0208333 | 0.0364583 | 0.0364583 | 0.0246063 | 0.0208333 | 0.0333333 | 0.0833333 | 22 mmø-15 mmø | 0.0729167 | 0.0492126
1187166 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 9.99955 | Domestic Hot Water 1 | Domestic Hot Water | Piping System: Domestic Hot Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15993 | 0.0833333 | 0.0241564 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1187209 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 15997 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1187250 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 16002 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1187304 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Hot Water | Piping System: Domestic Hot Water 1 | 1 | 805.833 | Level: Level 1 | Level : Level 1 | 16006 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1191033 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16012 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1191057 | Level 1 | 0.0260417 | 10.0003 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16015 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0248928 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1191132 | Level 1 | 0.0260417 | 10.0003 | yes | no | 0.0833333 | no | 0.0416667 | 10.0003 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16018 | 0.0833333 | 0.0249533 | 0.0208333 | 0.0246063 | 0.0248928 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1191157 | Level 1 | 0.0260417 | 10.0003 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16021 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0248928 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1191254 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16025 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1191325 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16034 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1191447 | Level 1 | 0.0260417 | 10.0003 | yes | no | 0.0833333 | no | 0.0416667 | 9.99975 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16037 | 0.0833333 | 0.0243556 | 0.0208333 | 0.0246063 | 0.0248928 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1191488 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16041 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1191671 | Level 1 | 0.0260417 | 10.0003 | yes | no | 0.0833333 | no | 0.0416667 | 9.99975 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16044 | 0.0833333 | 0.0243556 | 0.0208333 | 0.0246063 | 0.0248928 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1191708 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16049 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1191768 | Level 1 | 0.0260417 | 9.99971 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16052 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0243198 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1191793 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16055 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1191864 | Level 1 | 0.0260417 | 9.99971 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16058 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0243198 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1191888 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16061 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1191950 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 217.465 | Level: Level 1 | Level : Level 1 | 16066 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1191952 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16067 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1191983 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16072 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1192077 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 200 | Level: Level 1 | Level : Level 1 | 16076 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1192079 | Level 1 | 0.0260417 | 9.99975 | yes | no | 0.0833333 | no | 0.0416667 | 9.99971 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16077 | 0.0833333 | 0.0243198 | 0.0208333 | 0.0246063 | 0.0243556 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1192118 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16082 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1192229 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 9.99971 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16087 | 0.0833333 | 0.0243198 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1192254 | Level 1 | 0.0260417 | 10.0002 | no | yes | 0.0520833 | no | 0.0260417 | 10.0012 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 214.287 | Level: Level 1 | Level : Level 1 | 16090 | 0.0520833 | 0.0258562 | 0.0130208 | 0.0246063 | 0.0248425 | 0.0246063 | 0.0208333 | 0.0208333 | 0.0520833 | 15 mmø-15 mmø | 0.0492126 | 0.0492126
1192257 | Level 1 | 0.0260417 | 9.99975 | yes | no | 0.0833333 | no | 0.0416667 | 9.99971 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16091 | 0.0833333 | 0.0243198 | 0.0208333 | 0.0246063 | 0.0243556 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1192347 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 9.99971 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16096 | 0.0833333 | 0.0243198 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1192385 | Level 1 | 0.0260417 | 9.99975 | yes | no | 0.0833333 | no | 0.0416667 | 9.99971 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16100 | 0.0833333 | 0.0243198 | 0.0208333 | 0.0246063 | 0.0243556 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1192576 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 9.99971 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16104 | 0.0833333 | 0.0243198 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1192601 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16108 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1192660 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 9.99971 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16112 | 0.0833333 | 0.0243198 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1192685 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16116 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1192800 | Level 1 | 0.0260417 | 10.0003 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16119 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0248928 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1192832 | Level 1 | 0.0260417 | 9.99971 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16122 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0243198 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1192948 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 9.99971 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16126 | 0.0833333 | 0.0243198 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1192976 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16130 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1193070 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16134 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1193099 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16139 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1193233 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16142 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1193257 | Level 1 | 0.0260417 | 9.99971 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16145 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0243198 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1193332 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16149 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1193356 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16153 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1193421 | Level 1 | 0.0260417 | 9.99971 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16156 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0243198 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1193445 | Level 1 | 0.0260417 | 10.0003 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16159 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0248928 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1193505 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 217.462 | Level: Level 1 | Level : Level 1 | 16162 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1193507 | Level 1 | 0.0260417 | 9.99971 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16163 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0243198 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1193536 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 317.466 | Level: Level 1 | Level : Level 1 | 16167 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1193538 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16168 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1193639 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 317.466 | Level: Level 1 | Level : Level 1 | 16171 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1193641 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16172 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1193666 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 217.465 | Level: Level 1 | Level : Level 1 | 16175 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1193668 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16176 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1193738 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16181 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1193763 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16185 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1193828 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16189 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1193851 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 200 | Level: Level 1 | Level : Level 1 | 16192 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1193853 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16193 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1193909 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16197 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1193933 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 9.99971 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16201 | 0.0833333 | 0.0243198 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1193995 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16205 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1194019 | Level 1 | 0.0260417 | 10.0003 | yes | no | 0.0833333 | no | 0.0416667 | 9.99971 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16209 | 0.0833333 | 0.0243198 | 0.0208333 | 0.0246063 | 0.0249533 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1194090 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16212 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1194114 | Level 1 | 0.0260417 | 10.0003 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16215 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0248928 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1194168 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16218 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1194192 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16221 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1194253 | Level 1 | 0.0260417 | 9.99971 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16224 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0243198 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1194277 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16227 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1194365 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16230 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1194393 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16233 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1194448 | Level 1 | 0.046875 | 10 | no | no | 0.09375 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 200 | Level: Level 1 | Level : Level 1 | 16236 | 0.0520833 | 0.0410105 | 0.0234375 | 0.0410105 | 0.0410105 | 0.0246063 | 0.0208333 | 0.0375 | 0.09375 | 25 mmø-15 mmø | 0.082021 | 0.0492126
1194450 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16237 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1194484 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16241 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1194541 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16245 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1194565 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 9.99971 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16249 | 0.0833333 | 0.0243198 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1194631 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16253 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1194655 | Level 1 | 0.0260417 | 10 | yes | no | 0.0833333 | no | 0.0416667 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 798.223 | Level: Level 1 | Level : Level 1 | 16257 | 0.0833333 | 0.0246063 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0364583 | 0.0333333 | 0.0208333 | 0.0520833 | 22 mmø-15 mmø | 0.0492126 | 0.0729167
1194849 | Level 2 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 16265 | 0.0520833 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0246063 | 0.0208333 | 0.0541667 | 0.135417 | 40 mmø-15 mmø | 0.131234 | 0.0492126
1195157 | Level 2 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 16284 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1196313 | Level 2 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 199.994 | Level: Level 2 | Level : Level 2 | 16363 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1196792 | Level 2 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Hot Water | Piping System: Domestic Hot Water 1 | 1 | 317.463 | Level: Level 2 | Level : Level 2 | 16376 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1196925 | Level 2 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Hot Water | Piping System: Domestic Hot Water 1 | 1 | 317.462 | Level: Level 2 | Level : Level 2 | 16381 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1197052 | Level 2 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 200 | Level: Level 2 | Level : Level 2 | 16385 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1201842 | Level 2 | 0.0260417 | 10 | yes | no | 0.0520833 | no | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Hot Water | Piping System: Domestic Hot Water 1 | 1 | 616.57 | Level: Level 2 | Level : Level 2 | 16415 | 0.0520833 | 0.0208333 | 0.0130208 | 0.0208333 | 0.0208333 | 0.0246063 | 0.0208333 | 0.0208333 | 0.0520833 | 15 mmø-13 mmø | 0.0416667 | 0.0492126
1203511 | Level 1 | 0.0364583 | 10 | no | no | 0.0729167 | yes | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | -1400 | Level: Level 2 | Level : Level 2 | 16433 | 0.0520833 | 0.0328084 | 0.0182292 | 0.0328084 | 0.0328084 | 0.0246063 | 0.0208333 | 0.0291667 | 0.0729167 | 20 mmø-15 mmø | 0.0656168 | 0.0492126
1204887 | Level 1 | 0.0260417 | 10 | yes | no | 0.0520833 | no | 0.0260417 | 10 | Domestic Hot Water 1 | Domestic Cold Water | Piping System: Domestic Hot Water 1 | 1 | 1066 | Level: Level 1 | Level : Level 1 | 16461 | 0.0520833 | 0.0208333 | 0.0130208 | 0.0208333 | 0.0208333 | 0.0246063 | 0.0208333 | 0.0208333 | 0.0520833 | 15 mmø-13 mmø | 0.0416667 | 0.0492126
1205125 | Level 1 | 0.0677083 | 10 | no | no | 0.135417 | yes | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 889.794 | Level: Level 1 | Level : Level 1 | 16470 | 0.0520833 | 0.0656168 | 0.0338542 | 0.0656168 | 0.0656168 | 0.0246063 | 0.0208333 | 0.0541667 | 0.135417 | 40 mmø-15 mmø | 0.131234 | 0.0492126
1205168 | Level 1 | 0.0260417 | 10 | yes | no | 0.0520833 | no | 0.0260417 | 10 | Domestic Cold Water 1 | Domestic Cold Water | Piping System: Domestic Cold Water 1 | 1 | 1066 | Level: Level 1 | Level : Level 1 | 16476 | 0.0520833 | 0.0208333 | 0.0130208 | 0.0208333 | 0.0208333 | 0.0246063 | 0.0208333 | 0.0208333 | 0.0520833 | 15 mmø-13 mmø | 0.0416667 | 0.0492126
1207115 | TOF Footing | 0.171875 | 10 | no | no | 0.34375 | yes | 0.0885417 | 10.0006 | Sanitary 1 | Sanitary | Piping System: Sanitary 1 | 1 | -500.695 | Level: Level 1 | Level : Level 1 | 16489 | 0.177083 | 0.16468 | 0.0859375 | 0.164042 | 0.164044 | 0.082021 | 0.0708333 | 0.1375 | 0.34375 | 100 mmø-50 mmø | 0.328084 | 0.164042

# IfcFlowFitting: Wye 45 Deg Double - PVC - Sch 40 - DWV (5)
Type - ElementType: Wye 45 Deg Double - PVC - Sch 40 - DWV; Classification:  (UniFormat)
Mechanical - Loss Method: 0; System Classification: Sanitary; System Type: Piping System: Sanitary 1; System Name: Sanitary 1; Insulation Thickness: 0
Text - TemperatureRange: 0; PressureRange: 0; InteriorRoughnessCoefficient: 0
Other - SustainabilityPerformance: N/A; LossCoefficient: 0; AccessibilityPerformance: N/A; AssetAccountingType: FIXED; Constituents: N/A; Features: N/A; PressureClass: 0; Material: Material; WarrantyDurationParts: N/A; WarrantyGuarantorLabor: N/A; ExpectedLife: N/A; WarrantyDescription: N/A; WarrantyGuarantorParts: N/A; ReplacementCost: N/A; FittingLossFactor: 0; Grade: N/A; Reference: Type A - 1; WarrantyDurationLabor: N/A; ProductionYear: N/A; Shape: N/A; CodePerformance: N/A; NominalLength: 0; Size: Size; Lookup Table Name: M_Wye 45 Deg Double - PVC - Sch 40 - DWV.csv; ModelLabel: N/A; FlowrateLeakage: 0; Color: White; NominalHeight: 0; BendAngle: 0; NominalWidth: 0; ModelReference: N/A; JunctionRightAngle: 0; JunctionRightRadius: 0; BendRadius: 0; JunctionLeftRadius: 0; Max Angle 12: 45 deg; BarCode: N/A; TagNumber: N/A; Min Angle 12: 45 deg; WarrantyStartDate: N/A; JunctionLeftAngle: 0; AssetIdentifier: N/A; InstallationDate: N/A; SerialNumber: N/A
Identity Data - OmniClass Title: Pipework Fittings; Manufacturer: N/A; OmniClass Number: 23.60.30.11.14
Dimensions - Angle 1: 45 deg; Angle 2: 45 deg
Phasing - Phase Created: New Construction
Graphics - Use Annotation Scale: yes
Name (M_Wye 45 Deg Double - PVC - Sch 40 - DWV:Wye 45 Deg Double - PVC - Sch 40 - DWV:Wye 45 Deg Double - PVC - Sch 40 - DWV:...) | In | Host | Offset (mm) | Level | Socket Depth = Socket Insulation Depth | Tick Size | Center to Socket Bottom Branch = Center to Socket Bottom Run Label 2 = Center to Socket Bottom Branch Label = Length 8 | Fitting Outside Diameter | Nominal Radius | Center to Socket Bottom Run = Length 7 = Center to Socket Bottom Run Label 1 | Size = Overall Size | Socket Entrance Diameter | Socket Bottom to Socket Bottom Run | Wall Thickness | Socket Insulation Outside Diameter = Socket Outside Diameter | Nominal Diameter | Insulation Radius = Fitting Outside Radius | Length 4 = Length 2 | Length 6 | Socket Insulation Outside Radius = Socket Outside Radius | Length 1 = Length 3 | Length 5 | Mark
640709 | TOF Footing | Level : Level 1 | -500 | Level: Level 1 | 0.145833 | 0.15 | 0.53125 | 0.375 | 0.164042 | 0.15625 | 100 mmø-100 mmø-100 mmø-100 mmø | 0.376667 | 0.6875 | 0.0208333 | 0.418333 | 0.328084 | 0.1875 | 0.47877 | 0.504973 | 0.209167 | 0.780854 | 0.227747 | 2410
641447 | TOF Footing | Level : Level 1 | -500 | Level: Level 1 | 0.145833 | 0.15 | 0.53125 | 0.375 | 0.164042 | 0.15625 | 100 mmø-100 mmø-100 mmø-100 mmø | 0.376667 | 0.6875 | 0.0208333 | 0.418333 | 0.328084 | 0.1875 | 0.47877 | 0.504973 | 0.209167 | 0.780854 | 0.227747 | 2468
655240 | Level 1 | Level : Level 2 | -411 | Level: Level 2 | 0.145833 | 0.15 | 0.53125 | 0.375 | 0.164042 | 0.15625 | 100 mmø-100 mmø-100 mmø-100 mmø | 0.376667 | 0.6875 | 0.0208333 | 0.418333 | 0.328084 | 0.1875 | 0.47877 | 0.504973 | 0.209167 | 0.780854 | 0.227747 | 3416
659539 | Level 1 | Level : Level 2 | -1688.2 | Level: Level 2 | 0.125 | 0.116667 | 0.416667 | 0.291667 | 0.131234 | 0.135417 | 80 mmø-80 mmø-80 mmø-80 mmø | 0.293333 | 0.552083 | 0.01825 | 0.329833 | 0.262467 | 0.145833 | 0.383016 | 0.398144 | 0.164917 | 0.643433 | 0.178014 | 3821
663911 | Level 1 | Level : Level 2 | -1688.2 | Level: Level 2 | 0.145833 | 0.15 | 0.53125 | 0.375 | 0.164042 | 0.15625 | 100 mmø-100 mmø-100 mmø-100 mmø | 0.376667 | 0.6875 | 0.0208333 | 0.418333 | 0.328084 | 0.1875 | 0.47877 | 0.504973 | 0.209167 | 0.780854 | 0.227747 | 4347

# IfcFlowMovingDevice: 3.9 LPS - 0.8 Meter Head, M_Inline Pump - Circulator:3.9 LPS - 0.8 Meter Head:3.9 LPS - 0.8 Meter Head:1060890
In: Level 1
Type - ElementType: 3.9 LPS - 0.8 Meter Head; PredefinedType: CIRCULATOR; Classification:  (UniFormat)
Electrical - Loads - Apparent Load: 5834.04; Circuit Number: <unnamed>
Text - TemperatureRange: -293 - 393; OutletConnectionSize: 0; WorkingPressure: 0; Status: NEW
Electrical - Number of Poles: 3; Voltage: 4951.4; Load Classification: Appliance - Dwelling Unit
Identity Data - OmniClass Title: Pumps; Manufacturer: N/A; OmniClass Number: 23.60.30.21; Mark: HWP-1
Dimensions - Outside Diameter 1: 184 mm; Discharge Nominal Diameter: 0.131234; Suction Nominal Radius: 0.0656168; Suction Outside Diameter: 0.172244; Suction Outside Radius: 0.086122; Flange Height: 130 mm; Outside Diameter 2: 171 mm; Length 3: 62.064 mm; Outside Diameter 4: 62.064 mm; Length 1: 431 mm; Discharge Nominal Radius: 0.0656168; Flange Diameter: 102 mm; Suction Nominal Diameter: 0.131234; Housing Width: 152 mm; Length 2: 344.8 mm
Other - ConnectionSize: 25; PartLoadRatio: 0; WarrantyGuarantorParts: N/A; AccessibilityPerformance: N/A; FlowRateRange: 0.0105 - 0.018; AuxiliaryEnergyConsumption: 0; EnergySourceConsumption: 0; DrainSize: 0; AssetAccountingType: FIXED; Radius 3: 56.432 mm; ImpellerDiameter: 177; WarrantyDurationParts: N/A; MountingOffset: 0; Radius 1: 79.15 mm; BaseType: NONE; Radius 2: 72.8 mm; NominalLength: 0; ModelLabel: N/A; Grade: N/A; IsWaterStorageHeater: TRUE; NominalWidth: 0; CodePerformance: N/A; WarrantyDurationLabor: N/A; Constituents: N/A; Outside Radius 4: 31.032 mm; CoverLength: 0; Load: 0; FlowResistanceRange: 38610; ReplacementCost: N/A; Features: N/A; OutletTemperatureRange: 0; NominalEfficiency: 1.0; Length 4: 21.3482 mm; SustainabilityPerformance: N/A; Outside Radius 1: 92 mm; Power: 7500; NominalRotationSpeed: 48; CombustionTemperature: 0; HeatTransferSurfaceArea: 0; Flange Radius: 51 mm; WaterStorageCapacity: 0; Outside Radius 2: 85.5 mm; RotationSpeed: 48; PressureRating: 0; OverallEfficiency: 0.65; ModelReference: N/A; PartialLoadEfficiencyCurves: 0; PrimaryEnergyConsumption: 0; DriveConnectionType: OTHER; WarrantyDescription: N/A; CoverWidth: 0; Size: 0; NominalPartLoadRatio: 0; NominalEnergyConsumption: 0; OperationalEfficiency: 0; MechanicalEfficiency: 0.7; NominalHeight: 0; NetPositiveSuctionHead: 1000000; HeatOutput: 0; CombustionEfficiency: 0; PressureRise: 2500000; Material: N/A; Shape: N/A; WaterInletTemperatureRange: 0; Reference: Type M - 1; WarrantyGuarantorLabor: N/A; ExpectedLife: N/A; Flowrate: 0.015; ProductionYear: N/A; SerialNumber: N/A; InstallationDate: N/A; WarrantyStartDate: N/A; BarCode: N/A; AssetIdentifier: N/A; TagNumber: N/A
Phasing - Phase Created: New Construction
Mechanical - System Name: Domestic Hot Water 1; System Classification: Domestic Cold Water,Power; RPM: 1450
Constraints - Offset: -1400 mm; Level: Level: Level 2; Host: Level : Level 2

# IfcFlowMovingDevice: 400 mm, M_VAV Unit - Single Duct:400 mm:400 mm:567458
In: Level 1
Type - ElementType: 400 mm; PredefinedType: USERDEFINED; Classification:  (UniFormat)
Phasing - Phase Created: New Construction
Mechanical - Supply Air Pressure Drop: 6.06552; System Name: Mechanical Supply Air 1; System Classification: Supply Air
Mechanical - Flow - Air Flow: 15.0087
Other - InstallationDate: N/A; WarrantyStartDate: N/A; TagNumber: N/A; AssetIdentifier: N/A; SerialNumber: N/A; BarCode: N/A; ProductionYear: N/A; NominalHeight: 0; Reference: Type A - 1; WarrantyDescription: N/A; NetPositiveSuctionHead: 0; OverallEfficiency: 0; NominalWidth: 0; Flowrate: 0; NominalLength: 0; Material: N/A; HeatOutput: 0; DrainSize: 0; Half Air Outlet Width: 287.5 mm; AssetAccountingType: FIXED; Size: 0; CoverWidth: 0; NominalEnergyConsumption: 0; ImpellerDiameter: 0; ModelReference: N/A; FlowResistanceRange: 0; CoverLength: 0; NominalEfficiency: 1.0; ModelLabel: N/A; NominalPartLoadRatio: 0; WarrantyDurationParts: N/A; PressureRating: 0; AuxiliaryEnergyConsumption: 0; Features: N/A; MountingOffset: 0; FlowRateRange: 0; IsWaterStorageHeater: TRUE; ExpectedLife: N/A; HeatTransferSurfaceArea: 0; WarrantyGuarantorParts: N/A; WarrantyGuarantorLabor: N/A; OperationalEfficiency: 0; AccessibilityPerformance: N/A; SustainabilityPerformance: N/A; WaterInletTemperatureRange: 0; PrimaryEnergyConsumption: 0; Constituents: N/A; ConnectionSize: 0; Power: 0; Grade: N/A; Shape: N/A; WarrantyDurationLabor: N/A; OutletTemperatureRange: 0; PartialLoadEfficiencyCurves: 0; ReplacementCost: N/A; CombustionEfficiency: 0; NominalRotationSpeed: 0; PressureRise: 0; WaterStorageCapacity: 0; CodePerformance: N/A; PartLoadRatio: 0; Width 2: 88.9 mm; Load: 0; EnergySourceConsumption: 0; RotationSpeed: 0; MechanicalEfficiency: 0; CombustionTemperature: 0; Width 1: 108 mm
Identity Data - Mark: XXX; OmniClass Number: 23.75.70.21.24.14; OmniClass Title: Variable Volume Air Terminal Units; Manufacturer: N/A
Constraints - Offset: 3455.47 mm; Level: Level: Level 1; Host: Level : Level 1
Text - TemperatureRange: 0; WorkingPressure: 0; OutletConnectionSize: 0
Dimensions - Supply Air Outlet Height: 1.47638; Supply Air Inlet Radius: 0.656168; Overall Length: 381 mm; Supply Air Outlet Width: 1.88648; Supply Air Inlet Diameter: 1.31234

# IfcFlowSegment: Pipe Types:Cold Water:677372 (822)
Type - ElementType: Pipe Types:Cold Water:677372
Text - LeakageCurve: 0; FluidFlowLeakage: 0; PressureRange: 0; TemperatureRange: 0; InteriorRoughnessCoefficient: 0; WorkingPressure: 0; InnerDiameter: 1; NominalDiameter: 1; InvertElevation: 1; Gradient: 0; OuterDiameter: 1
Identity Data - Manufacturer: N/A
Other - Classification Description: Pipes for General Use; ModelLabel: N/A; AssetAccountingType: FIXED; WarrantyDescription: N/A; ExpectedLife: N/A; NominalLength: 0; WarrantyGuarantorParts: N/A; Grade: N/A; Constituents: N/A; NominalHeight: 0; WarrantyGuarantorLabor: N/A; Color: White; WarrantyDurationParts: N/A; WarrantyDurationLabor: N/A; Reference: Type A - 1; Classification Code: 23-60 30 11 11; ReplacementCost: N/A; AccessibilityPerformance: N/A; SustainabilityPerformance: N/A; ModelReference: N/A; CodePerformance: N/A; Material: Material; ProductionYear: N/A; Features: N/A; Shape: N/A; Size: Size; NominalWidth: 0; SerialNumber: N/A; WarrantyStartDate: N/A; BarCode: N/A; TagNumber: N/A; AssetIdentifier: N/A; InstallationDate: N/A
Phasing - Phase Created: New Construction
Mechanical - Flow - Additional Flow: 0
Mechanical - System Type: Piping System: Domestic Cold Water 1; Connection Type: Generic; System Classification: Domestic Cold Water
Constraints - Horizontal Justification: 0; Vertical Justification: 0
Name (Pipe Types:Cold Water:...) | In | Friction Factor | Reynolds Number | Flow State | Pressure Drop | Velocity | Flow | Fixture Units | Relative Roughness | Friction | Mark | Area (mm2) | Schedule/Type | Roughness | Material | Pipe Segment | Diameter | Section | Invert Elevation (mm) | System Name | End Offset (mm) | Start Offset (mm) = Offset (mm) | Reference Level | Slope | Outer Diameter | Size = Overall Size | Inner Diameter | Length (mm)
