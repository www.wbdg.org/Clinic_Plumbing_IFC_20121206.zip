Properties of the parts of a building model (IFC2X3), part 18 of 29

# IfcFlowSegment: Pipe Types:Cold Water:677372 (822)
Name (Pipe Types:Cold Water:...) | In | Friction Factor | Reynolds Number | Flow State | Pressure Drop | Velocity | Flow | Fixture Units | Relative Roughness | Friction | Mark | Area (mm2) | Schedule/Type | Roughness | Material | Pipe Segment | Diameter | Section | Invert Elevation (mm) | System Name | End Offset (mm) | Start Offset (mm) = Offset (mm) | Reference Level | Slope | Outer Diameter | Size = Overall Size | Inner Diameter | Length (mm)
677372 | Level 1 | 0.0130723 | 66232.2 | 2 | 1765.78 | 15.0447 | 0.0334201 | 2.25 | 6381.89 | 786.845 | 1650 | 42977.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 65 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 684.009
677462 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 1652 | 148388 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 322 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 726.665
677565 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 1653 | 496176 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 322 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 2429.81
677574 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 1654 | 11577.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 273 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 56.6974
677658 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 1655 | 324932 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 258 | -561.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.333333 | 100 mmø | 0.320013 | 1034.29
677668 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 1656 | 2086856 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 258 | -561.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.333333 | 100 mmø | 0.320013 | 6642.67
677731 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 1657 | 623001 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 258 | -561.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.333333 | 100 mmø | 0.320013 | 1983.07
677778 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 11216.5 | 0 | 1658 | 73961.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.104987 | 260 | -526.923 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.104167 | 32 mmø | 0.0934711 | 735.706
677788 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 1659 | 994623 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 257 | -561.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.333333 | 100 mmø | 0.320013 | 3165.98
677792 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 11216.5 | 0 | 1660 | 60451.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.104987 | 262 | -526.923 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.104167 | 32 mmø | 0.0934711 | 601.326
677964 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 11216.5 | 0 | 1661 | 66959.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.104987 | 260 | -526.923 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.104167 | 32 mmø | 0.0934711 | 666.061
678183 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 11216.5 | 0 | 1663 | 254431 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.104987 | 263 | -526.923 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.104167 | 32 mmø | 0.0934711 | 2530.87
678205 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1666 | 17053.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 269 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 271.421
678215 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 11216.5 | 0 | 1667 | 135140 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.104987 | 263 | -526.923 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.104167 | 32 mmø | 0.0934711 | 1344.26
678220 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1668 | 15239.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 266 | 491.895 | Domestic Cold Water 1 | 500 | 500 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 242.538
678268 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1669 | 61434 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 266 | -495.216 | Domestic Cold Water 1 | 482.538 | -495.216 | Level: Level 1 |  | 0.0625 | 20 mmø | 0.0531824 | 977.753
678336 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1670 | 252813 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 266 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 4023.64
678337 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 11216.5 | 0 | 1671 | 923657 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.104987 | 262 | -526.923 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.104167 | 32 mmø | 0.0934711 | 9187.79
678402 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1672 | 272097 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 267 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 4330.57
678449 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1673 | 3766.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 285 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 47.9604
678459 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1674 | 42016.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 271 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 534.973
678516 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1675 | 101588 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 275 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 808.415
678525 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 1676 | 313448 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 340 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 1534.98
678557 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1677 | 102241 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 276 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 813.608
678725 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1678 | 22561.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 281 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 287.267
678731 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1679 | 8722.68 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 270 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 111.061
678795 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1680 | 19946.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 279 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 253.97
678820 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1681 | 911097 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 284 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 14500.6
678834 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1682 | 50584.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 284 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 805.075
678841 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1683 | 17752.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 284 | 491.895 | Domestic Cold Water 1 | 500 | 500 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 282.538
678879 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1684 | 61434 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 284 | -495.216 | Domestic Cold Water 1 | 482.538 | -495.216 | Level: Level 1 |  | 0.0625 | 20 mmø | 0.0531824 | 977.753
678904 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1685 | 16915 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 282 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 269.211
678944 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1686 | 52038.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 288 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 662.58
678949 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1687 | 378832 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 278 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 4823.44
678951 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1688 | 31365.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 288 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 399.363
678990 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1689 | 63209.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 286 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 804.807
679011 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1690 | 171365 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 728 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 3636.49
679023 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1691 | 378053 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 289 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 3008.45
679160 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1695 | 37140.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 291 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 788.139
679175 | Level 1 | 0.0142324 | 100715 | 2 | 97470.6 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 1696 | 200994 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 67 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 4265.23
679185 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 1697 | 478068 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 294 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 2341.14
679205 | Level 1 | 0.0142324 | 100715 | 2 | 102949 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 1698 | 212291 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 67 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 4504.95
679261 | Level 1 | 0.0142324 | 100715 | 2 | 19187.5 | 34.7884 | 0.0334201 | 2.25 | 4196.85 | 6965.4 | 1700 | 39566.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 67 | -498.391 | Domestic Cold Water 1 | 341.238 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 839.628
679350 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 1702 | 1455379 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 293 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 7127.1
679369 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 1703 | 13385.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 316 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 65.5515
679377 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 1704 | 36264.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 305 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 230.865
679396 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1705 | 117214 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 299 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 932.76
679414 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1706 | 855214 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 298 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 6805.58
679429 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1707 | 121394 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 298 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 966.025
679490 | Level 1 | 0.0112912 | 55468.5 | 2 | 39.8029 | 5.86225 | 0.0601563 | 10 | 13716.5 | 48.0116 | 1709 | 31753.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 9 | 404.6 | Domestic Cold Water 1 | 657.288 | 404.6 | Level: Level 1 |  | 0.125 | 40 mmø | 0.114304 | 252.688
679565 | Level 1 | 0.0122545 | 85661.5 | 2 | 132.287 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 1710 | 6918.69 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 8 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 88.0915
679569 | Level 1 | 0.0122545 | 85661.5 | 2 | 283.49 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 1711 | 14826.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 8 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 188.779
679583 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1712 | 19446.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 195 | 385.552 | Domestic Cold Water 1 | 798.223 | 385.554 | Level: Level 1 | 3162.02 | 0.0416667 | 15 mmø | 0.0349738 | 412.67
679584 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1713 | 24135.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 195 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 512.168
679588 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1714 | 4188.62 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 195 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 88.8853
679590 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1715 | 103499 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 298 | -485.691 | Domestic Cold Water 1 | 337.925 | -485.691 | Level: Level 1 |  | 0.125 | 40 mmø | 0.114304 | 823.616
679764 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1716 | 58391.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 299 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 464.662
679804 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1717 | 507987 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 303 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 8084.87
679814 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1718 | 164583 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 304 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 1309.71
679819 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1719 | 16259.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 303 | 491.895 | Domestic Cold Water 1 | 500 | 500 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 258.781
679866 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1720 | 61434 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 303 | -495.216 | Domestic Cold Water 1 | 482.538 | -495.216 | Level: Level 1 |  | 0.0625 | 20 mmø | 0.0531824 | 977.753
679922 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1721 | 30726.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 301 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 489.027
680032 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1722 | 114204 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 190 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 2423.49
680037 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1723 | 246766 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 296 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 1963.7
680041 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1724 | 46719.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 190 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 991.425
680082 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1726 | 40308.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 190 | -498.391 | Domestic Cold Water 1 | 356.975 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 855.366
680108 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1727 | 19446.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 190 | 385.551 | Domestic Cold Water 1 | 798.223 | 385.553 | Level: Level 1 | 3162.02 | 0.0416667 | 15 mmø | 0.0349738 | 412.67
680109 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1728 | 1827.52 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 190 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 38.7813
680113 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1729 | 967.371 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 190 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 20.5282
680151 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1730 | 29811.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 192 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 632.626
680178 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1731 | 346279 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 309 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 2755.6
680183 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 1732 | 1472.45 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 310 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 9.37392
680267 | Level 1 | 0.0112912 | 55468.5 | 2 | 39.8029 | 5.86225 | 0.0601563 | 10 | 13716.5 | 48.0116 | 1734 | 31753.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 11 | 404.6 | Domestic Cold Water 1 | 657.288 | 404.6 | Level: Level 1 |  | 0.125 | 40 mmø | 0.114304 | 252.688
680315 | Level 1 | 0.0122545 | 85661.5 | 2 | 158.566 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 1735 | 8293.08 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 10 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 105.591
680316 | Level 1 | 0.0122545 | 85661.5 | 2 | 344.306 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 1736 | 18007.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 10 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 229.277
680330 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1737 | 19446.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 184 | 385.548 | Domestic Cold Water 1 | 798.223 | 385.55 | Level: Level 1 | 2380.39 | 0.0416667 | 15 mmø | 0.0349738 | 412.673
680331 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1738 | 6397.22 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 184 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 135.753
680334 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1739 | 30731.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 184 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 652.139
680336 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1740 | 103499 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 309 | -485.691 | Domestic Cold Water 1 | 337.925 | -485.691 | Level: Level 1 |  | 0.125 | 40 mmø | 0.114304 | 823.616
680371 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1741 | 86035.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 307 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 684.645
680454 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1742 | 285113 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 314 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 6050.28
680461 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 1743 | 580243 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 315 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 3693.94
680483 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1744 | 50489.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 314 | 194.67 | Domestic Cold Water 1 | 200 | 200 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1071.43
680490 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1745 | 32237.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 314 | -498.391 | Domestic Cold Water 1 | 185.713 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 684.103
680494 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1746 | 6866.54 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 314 | 194.67 | Domestic Cold Water 1 | 200 | 200 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 145.713
680514 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1747 | 18720.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 312 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 397.262
680530 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1748 | 150339 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 173 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 3190.28
680541 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 1749 | 89542 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 295 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 570.042
680545 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1750 | 31875.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 173 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 676.425
680615 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1752 | 40308.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 173 | -498.391 | Domestic Cold Water 1 | 356.975 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 855.366
680641 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1753 | 19446.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 173 | 385.55 | Domestic Cold Water 1 | 798.223 | 385.55 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 412.673
680642 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1754 | 1632.16 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 173 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 34.6355
680646 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1755 | 1565.96 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 173 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 33.2307
680654 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 1756 | 370802 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 318 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 2360.6
680662 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 1757 | 166253 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 319 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 814.155
680666 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 1758 | 2387.85 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 318 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 15.2015
680878 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 1761 | 76239.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 318 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 485.355
680978 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1762 | 18720.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 175 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 397.262
681046 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 1763 | 76099.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 321 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 484.463
681051 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 1764 | 450889 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 489 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 2208.04
681153 | Level 1 | 0.0106702 | 40650.5 | 2 | 7.65168 | 3.14849 | 0.0601563 | 10 | 18716.5 | 9.59125 | 1766 | 38195.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 48 | 410.95 | Domestic Cold Water 1 | 654.113 | 410.95 | Level: Level 1 |  | 0.166667 | 50 mmø | 0.155971 | 243.163
681261 | Level 1 | 0.0122545 | 85661.5 | 2 | 178.003 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 1770 | 9309.66 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 47 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 118.534
681265 | Level 1 | 0.0122545 | 85661.5 | 2 | 332.072 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 1771 | 17367.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 47 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 221.13
681283 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1772 | 19446.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 178 | 385.551 | Domestic Cold Water 1 | 798.223 | 385.553 | Level: Level 1 | 3162.02 | 0.0416667 | 15 mmø | 0.0349738 | 412.67
681284 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1773 | 7007.03 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 178 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 148.694
681287 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1774 | 31440.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 178 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 667.196
681289 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 1775 | 127378 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 321 | -479.341 | Domestic Cold Water 1 | 331.575 | -479.341 | Level: Level 1 |  | 0.166667 | 50 mmø | 0.155971 | 810.916
681329 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18716.5 | 0 | 1776 | 94482.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.164042 | 321 | -536.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.166667 | 50 mmø | 0.155971 | 601.493
681358 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1777 | 49656.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 325 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 632.243
681368 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 1778 | 598606 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 322 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 2931.42
681373 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1779 | 57920.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 168 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 737.463
681425 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1780 | 36028.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 168 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 458.725
681470 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1782 | 90075.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 168 | -492.041 | Domestic Cold Water 1 | 654.831 | -492.041 | Level: Level 1 |  | 0.0833333 | 25 mmø | 0.0740157 | 1146.87
681499 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1783 | 5074.58 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 167 | 690.532 | Domestic Cold Water 1 | 798.223 | 690.538 | Level: Level 1 | 945.057 | 0.0416667 | 15 mmø | 0.0349738 | 107.686
681503 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1784 | 2608.64 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 167 | 670.933 | Domestic Cold Water 1 | 676.263 | 676.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 55.3571
681506 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1785 | 3911.13 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 167 | 670.933 | Domestic Cold Water 1 | 676.263 | 676.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 82.9967
681516 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1786 | 33958.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 326 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 432.375
681523 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1787 | 61833.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 325 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 787.287
681559 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1789 | 52731.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 326 | -492.041 | Domestic Cold Water 1 | 179.363 | -492.041 | Level: Level 1 |  | 0.0833333 | 25 mmø | 0.0740157 | 671.403
681610 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1790 | 20375.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 327 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 259.426
681663 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1791 | 68587.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 333 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1455.48
681670 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 1792 | 467185 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 323 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 2287.84
681674 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1793 | 58972 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 333 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1251.43
681710 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1795 | 58568.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 333 | -498.391 | Domestic Cold Water 1 | 744.475 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 1242.87
681742 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1798 | 5499.79 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 333 | 753.433 | Domestic Cold Water 1 | 758.763 | 758.763 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 116.709
681791 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1799 | 10962 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 331 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 232.622
681805 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1800 | 47741.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 199 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 607.865
681812 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 1801 | 1916101 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 329 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 9383.29
681858 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1803 | 52731.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 199 | -492.041 | Domestic Cold Water 1 | 179.363 | -492.041 | Level: Level 1 |  | 0.0833333 | 25 mmø | 0.0740157 | 671.403
681916 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1804 | 27517.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 198 | 214.288 | Domestic Cold Water 1 | 798.223 | 214.29 | Level: Level 1 | 4410.15 | 0.0416667 | 15 mmø | 0.0349738 | 583.934
681917 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1805 | 3301.08 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 198 | 194.67 | Domestic Cold Water 1 | 200 | 200 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 70.0512
681930 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1807 | 2130.88 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 199 | 188.72 | Domestic Cold Water 1 | 200 | 200 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 27.1313
682005 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1808 | 45851.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 201 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 583.804
682095 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 1809 | 141899 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 339 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 694.89
682102 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 1810 | 629617 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 670 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 3083.28
682149 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 1812 | 400666 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 478 | -561.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.333333 | 100 mmø | 0.320013 | 1275.36
682159 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1813 | 271476 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 475 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 2160.34
682184 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1814 | 178694 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 477 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 1422
682197 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1815 | 194279 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 477 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 1546.03
682236 | Level 1 | 0.0112912 | 55468.5 | 2 | 39.8029 | 5.86225 | 0.0601563 | 10 | 13716.5 | 48.0116 | 1817 | 31753.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 13 | 404.6 | Domestic Cold Water 1 | 657.288 | 404.6 | Level: Level 1 |  | 0.125 | 40 mmø | 0.114304 | 252.688
682280 | Level 1 | 0.0122545 | 85661.5 | 2 | 420.313 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 1818 | 21982.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 12 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 279.891
682281 | Level 1 | 0.0122545 | 85661.5 | 2 | 740.892 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 1819 | 38749 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 12 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 493.368
682295 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1820 | 19446.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 139 | 385.551 | Domestic Cold Water 1 | 798.223 | 385.553 | Level: Level 1 | 3162.22 | 0.0416667 | 15 mmø | 0.0349738 | 412.67
682296 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1821 | 14610.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 139 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 310.05
682300 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1822 | 31017.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 139 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 658.213
682302 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1823 | 103499 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 477 | -485.691 | Domestic Cold Water 1 | 337.925 | -485.691 | Level: Level 1 |  | 0.125 | 40 mmø | 0.114304 | 823.616
682529 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1824 | 111942 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 162 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 2375.48
682534 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 1825 | 1896.39 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 676 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 9.28679
682538 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1826 | 23526.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 162 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 499.245
682575 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1828 | 56565.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 162 | -498.391 | Domestic Cold Water 1 | 701.975 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 1200.37
682607 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1829 | 3188.32 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 162 | 730.557 | Domestic Cold Water 1 | 798.223 | 730.565 | Level: Level 1 | 659.554 | 0.0416667 | 15 mmø | 0.0349738 | 67.6583
682608 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1830 | 1777.96 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 162 | 710.933 | Domestic Cold Water 1 | 716.263 | 716.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 37.7295
682612 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1831 | 1695.62 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 162 | 710.933 | Domestic Cold Water 1 | 716.263 | 716.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 35.9821
682643 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1832 | 47243.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 164 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1002.54
682671 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1833 | 118558 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 344 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 943.452
682678 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 23716.5 | 0 | 1834 | 313448 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.213255 | 335 | -542.798 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.208333 | 65 mmø | 0.197638 | 1534.98
682682 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1835 | 196793 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 344 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 1566.03
682725 | Level 1 | 0.0112912 | 55468.5 | 2 | 39.8029 | 5.86225 | 0.0601563 | 10 | 13716.5 | 48.0116 | 1837 | 31753.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 7 | 404.6 | Domestic Cold Water 1 | 657.288 | 404.6 | Level: Level 1 |  | 0.125 | 40 mmø | 0.114304 | 252.688
682755 | Level 1 | 0.0122545 | 85661.5 | 2 | 38.1433 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 1838 | 1994.91 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 6 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 25.4
682756 | Level 1 | 0.0122545 | 85661.5 | 2 | 524.475 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 1839 | 27430.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 6 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 349.253
682779 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1840 | 19446.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 153 | 385.549 | Domestic Cold Water 1 | 798.223 | 385.55 | Level: Level 1 | 4100.48 | 0.0416667 | 15 mmø | 0.0349738 | 412.673
682780 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1841 | 2305.92 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 153 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 48.9332
682783 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1842 | 33096.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 153 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 702.328
682785 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1843 | 103499 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 344 | -485.691 | Domestic Cold Water 1 | 337.925 | -485.691 | Level: Level 1 |  | 0.125 | 40 mmø | 0.114304 | 823.616
682822 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1844 | 30393.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 342 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 241.866
683557 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1856 | 264299 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 350 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 2103.23
683562 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 1857 | 1709722 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 527 | -561.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.333333 | 100 mmø | 0.320013 | 5442.21
683566 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1858 | 133961 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 350 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 1066.03
683604 | Level 1 | 0.0112912 | 55468.5 | 2 | 39.8029 | 5.86225 | 0.0601563 | 10 | 13716.5 | 48.0116 | 1860 | 31753.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 50 | 404.6 | Domestic Cold Water 1 | 657.288 | 404.6 | Level: Level 1 |  | 0.125 | 40 mmø | 0.114304 | 252.688
683630 | Level 1 | 0.0122545 | 85661.5 | 2 | 116.363 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 1861 | 6085.83 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 49 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 77.4871
683631 | Level 1 | 0.0122545 | 85661.5 | 2 | 260.347 | 13.9811 | 0.0601563 | 10 | 8881.89 | 457.719 | 1862 | 13616.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 49 | 676.964 | Domestic Cold Water 1 | 688.244 | 688.244 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 173.368
683645 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1863 | 19446.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 150 | 385.551 | Domestic Cold Water 1 | 798.223 | 385.553 | Level: Level 1 | 3162.22 | 0.0416667 | 15 mmø | 0.0349738 | 412.67
683646 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1864 | 5072.73 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 150 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 107.647
683650 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1865 | 36672.4 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 150 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 778.213
683652 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1866 | 103499 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 350 | -485.691 | Domestic Cold Water 1 | 337.925 | -485.691 | Level: Level 1 |  | 0.125 | 40 mmø | 0.114304 | 823.616
683689 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 13716.5 | 0 | 1867 | 29344.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.131234 | 348 | -530.098 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.125 | 40 mmø | 0.114304 | 233.517
683822 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1868 | 19334 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 362 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 246.168
683827 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 38401.6 | 0 | 1869 | 150035 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.328084 | 346 | -561.448 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.333333 | 100 mmø | 0.320013 | 477.577
683832 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1870 | 147416 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 356 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 2346.21
683843 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1871 | 65752.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 683 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 1046.49
683889 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1873 | 52796.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 171 | -488.866 | Domestic Cold Water 1 | -488.866 | 351.419 | Level: Level 1 |  | 0.0625 | 20 mmø | 0.0531824 | 840.284
683915 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1874 | 19446.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 170 | 385.549 | Domestic Cold Water 1 | 798.223 | 385.55 | Level: Level 1 | 4100.48 | 0.0416667 | 15 mmø | 0.0349738 | 412.673
683920 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1875 | 6109.54 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 170 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 129.649
683924 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1876 | 2107.39 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 170 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 44.7202
683965 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1877 | 36935.9 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 356 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 587.853
683986 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1878 | 152471 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 360 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 3235.53
683993 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1879 | 167231 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 354 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 2661.56
683998 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1880 | 33525.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 360 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 711.425
684040 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1882 | 40308.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 360 | -498.391 | Domestic Cold Water 1 | 356.975 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 855.366
684074 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1885 | 2925.21 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 360 | 365.933 | Domestic Cold Water 1 | 371.263 | 371.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 62.0748
684110 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1886 | 30008.3 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 358 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 636.796
684132 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1887 | 37619 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 365 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 598.725
684143 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1889 | 57563.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 366 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 916.146
684201 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1891 | 76914.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 366 | -495.216 | Domestic Cold Water 1 | 728.919 | -495.216 | Level: Level 1 |  | 0.0625 | 20 mmø | 0.0531824 | 1224.13
684237 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1894 | 6866.02 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 361 | 743.433 | Domestic Cold Water 1 | 748.763 | 748.763 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 145.701
684427 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1899 | 3222.66 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 370 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 41.0322
684451 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1901 | 179597 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 369 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 2858.38
684473 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1902 | 59082.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 365 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 940.323
684511 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1904 | 80527.5 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 365 | -495.216 | Domestic Cold Water 1 | 786.419 | -495.216 | Level: Level 1 |  | 0.0625 | 20 mmø | 0.0531824 | 1281.63
684541 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1907 | 11024.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 367 | 800.933 | Domestic Cold Water 1 | 806.263 | 806.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 233.949
684582 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1908 | 71546.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 364 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 1138.69
684606 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1909 | 141327 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 374 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 2999.06
684613 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1910 | 486412 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 375 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 6193.18
684617 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1911 | 51432.2 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 374 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 1091.43
684676 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1913 | 58922.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 374 | -498.391 | Domestic Cold Water 1 | 751.975 | -498.391 | Level: Level 1 |  | 0.0416667 | 15 mmø | 0.0349738 | 1250.37
684710 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1916 | 11495.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 374 | 760.933 | Domestic Cold Water 1 | 766.263 | 766.263 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 243.949
684739 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4196.85 | 0 | 1917 | 19204.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0492126 | 372 | -518.008 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0416667 | 15 mmø | 0.0349738 | 407.533
684786 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1918 | 38390 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 378 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 610.996
684793 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 8881.89 | 0 | 1919 | 57996.7 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.082021 | 384 | -523.958 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0833333 | 25 mmø | 0.0740157 | 738.437
684797 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1920 | 58709.8 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 378 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 934.396
684815 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1922 | 78160.1 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 378 | -495.216 | Domestic Cold Water 1 | 748.741 | -495.216 | Level: Level 1 |  | 0.0625 | 20 mmø | 0.0531824 | 1243.96
684835 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1923 | 57213.6 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 379 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 910.583
684840 | Level 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6381.89 | 0 | 1924 | 203330 | Pipe Schedule Types: A | 0.00000833333 | Copper | Copper - A | 0.0656168 | 383 | -520.783 | Domestic Cold Water 1 | -512.678 | -512.678 | Level: Level 1 | 0 | 0.0625 | 20 mmø | 0.0531824 | 3236.1
