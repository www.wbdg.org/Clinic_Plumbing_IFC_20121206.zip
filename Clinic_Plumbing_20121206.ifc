Properties of the parts of a building model (IFC2X3), part 9 of 29

# IfcFlowFitting: Elbow - Generic (1654)
Name (M_Elbow - Generic:Elbow - Generic:Elbow - Generic:...) | In | Offset (mm) | Level | Host | Fitting Outside Radius = Insulation Radius | Center Radius | Overall Size = Size | System Classification | Loss Method | System Type | System Name | Angle (deg) | Nominal Radius | Center to End | Fitting Outside Diameter | Tick Size | Nominal Diameter | Mark
1204576 | Level 1 | 1066 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16458
1204872 | Level 1 | 1066 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16459
1204889 | Level 1 | 1066 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Hot Water 1 | Domestic Hot Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16462
1205123 | Level 1 | 914.4 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16469
1205127 | Level 1 | 914.4 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16471
1205165 | Level 1 | 1066 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 13 mmø-13 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0208333 | 0.046875 | 0.0520833 | 0.0208333 | 0.0416667 | 16475
1205170 | Level 1 | 1066 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16477
1205172 | Level 1 | 1066 | Level: Level 1 | Level : Level 1 | 0.0260417 | 0.046875 | 15 mmø-15 mmø | Domestic Cold Water | 1 | Piping System: Domestic Cold Water 1 | Domestic Cold Water 1 | 90 | 0.0246063 | 0.046875 | 0.0520833 | 0.0208333 | 0.0492126 | 16478
1207101 | TOF Footing | -500 | Level: Level 1 | Level : Level 1 | 0.0885417 | 0.109375 | 50 mmø-50 mmø | Sanitary | 1 | Piping System: Sanitary 1 | Sanitary 1 | 44.6016 | 0.082021 | 0.0448598 | 0.177083 | 0.029052 | 0.164042 | 16484

# IfcFlowFitting: Tee - Generic (541)
Type - ElementType: Tee - Generic; Classification:  (UniFormat)
Other - InstallationDate: N/A; SerialNumber: N/A; BarCode: N/A; JunctionLeftRadius: 0; AssetIdentifier: N/A; JunctionLeftAngle: 0; JunctionRightAngle: 0; JunctionRightRadius: 0; TagNumber: N/A; WarrantyStartDate: N/A; BendRadius: 0; WarrantyDurationParts: N/A; SustainabilityPerformance: N/A; ExpectedLife: N/A; FittingLossFactor: 0; WarrantyGuarantorParts: N/A; PressureClass: 0; Material: Material; LossCoefficient: 0; FlowrateLeakage: 0; Lookup Table Name: M_Pipe Fitting - Generic.csv; AssetAccountingType: FIXED; Grade: N/A; ModelLabel: N/A; AccessibilityPerformance: N/A; CodePerformance: N/A; Size: Size; BendAngle: 0; ProductionYear: N/A; NominalHeight: 0; Reference: Type A - 1; WarrantyDurationLabor: N/A; WarrantyGuarantorLabor: N/A; WarrantyDescription: N/A; Constituents: N/A; NominalLength: 0; Color: White; ReplacementCost: N/A; Shape: N/A; Features: N/A; NominalWidth: 0; ModelReference: N/A
Graphics - Use Annotation Scale: yes
Mechanical - K Coefficient Table: Tee; Insulation Thickness: 0
Phasing - Phase Created: New Construction
Text - InteriorRoughnessCoefficient: 0; TemperatureRange: 0; PressureRange: 0
Identity Data - Manufacturer: N/A; OmniClass Title: Pipework Fittings; OmniClass Number: 23.60.30.11.14
Name (M_Tee - Generic:Tee - Generic:Tee - Generic:...) | In | Center to End Label | Angle 1 (deg) | Fitting Outside Radius = Insulation Radius | Angle (deg) | Center to End | Fitting Outside Diameter | Size = Overall Size | Nominal Diameter | Tick Size | Nominal Radius | System Type | System Classification | Loss Method | System Name | Mark | Level | Offset (mm) | Host
577335 | TOF Footing | 0.0885417 | 90 | 0.046875 | 45 | 0.0885417 | 0.09375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.0375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 26 | Level: Level 1 | -500 | Level : Level 1
577811 | TOF Footing | 0.415597 | 44.9363 | 0.171875 | 44.9363 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 96 | Level: Level 1 | -500 | Level : Level 1
578060 | TOF Footing | 0.0885417 | 90 | 0.046875 | 135 | 0.0885417 | 0.09375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.0375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 137 | Level: Level 1 | -500 | Level : Level 1
627924 | TOF Footing | 0.0885417 | 90 | 0.046875 | 45 | 0.0885417 | 0.09375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.0375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 636 | Level: Level 1 | -500 | Level : Level 1
633207 | TOF Footing | 0.269224 | 51.6208 | 0.130208 | 128.379 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1399 | Level: Level 1 | -500 | Level : Level 1
633294 | TOF Footing | 0.414943 | 45 | 0.171875 | 135 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1411 | Level: Level 1 | -500 | Level : Level 1
633397 | TOF Footing | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1419 | Level: Level 1 | -500 | Level : Level 1
633455 | TOF Footing | 0.350984 | 52.1815 | 0.171875 | 127.819 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1427 | Level: Level 1 | -500 | Level : Level 1
633525 | TOF Footing | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1434 | Level: Level 1 | -500 | Level : Level 1
633632 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1448 | Level: Level 1 | -500 | Level : Level 1
633747 | TOF Footing | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1470 | Level: Level 1 | -500 | Level : Level 1
633837 | TOF Footing | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1472 | Level: Level 1 | -500 | Level : Level 1
633885 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1484 | Level: Level 1 | -500 | Level : Level 1
634095 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1504 | Level: Level 1 | 2900 | Level : Level 1
634187 | TOF Footing | 0.414308 | 45.0621 | 0.171875 | 134.938 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1520 | Level: Level 1 | -500 | Level : Level 1
634238 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1531 | Level: Level 1 | 231.963 | Level : Level 1
634291 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1546 | Level: Level 1 | -500 | Level : Level 1
634374 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1558 | Level: Level 1 | -500 | Level : Level 1
634425 | Level 1 | 0.171875 | 90 | 0.130208 | 90 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1569 | Level: Level 1 | 0 | Level : Level 1
634444 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1577 | Level: Level 1 | 0 | Level : Level 1
634488 | TOF Footing | 0.410102 | 45.4775 | 0.171875 | 134.523 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1589 | Level: Level 1 | -500 | Level : Level 1
634603 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1614 | Level: Level 1 | 0 | Level : Level 1
634652 | TOF Footing | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1624 | Level: Level 1 | -500 | Level : Level 1
634736 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1628 | Level: Level 1 | -300 | Level : Level 1
634779 | TOF Footing | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1637 | Level: Level 1 | -500 | Level : Level 1
634823 | TOF Footing | 0.171875 | 90 | 0.130208 | 90 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1657 | Level: Level 1 | -500 | Level : Level 1
635005 | TOF Footing | 0.171875 | 90 | 0.130208 | 90 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1674 | Level: Level 1 | -500 | Level : Level 1
635040 | TOF Footing | 0.314351 | 45 | 0.130208 | 135 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1684 | Level: Level 1 | -500 | Level : Level 1
635117 | TOF Footing | 0.314351 | 45 | 0.130208 | 45 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1707 | Level: Level 1 | -500 | Level : Level 1
635228 | TOF Footing | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1731 | Level: Level 1 | -300 | Level : Level 1
635269 | TOF Footing | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1737 | Level: Level 1 | -300 | Level : Level 1
635372 | TOF Footing | 0.314351 | 45 | 0.130208 | 135 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1765 | Level: Level 1 | -500 | Level : Level 1
635647 | TOF Footing | 0.171875 | 90 | 0.130208 | 90 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1778 | Level: Level 1 | -500 | Level : Level 1
635699 | TOF Footing | 0.401659 | 46.3334 | 0.171875 | 133.667 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1791 | Level: Level 1 | -500 | Level : Level 1
635819 | TOF Footing | 0.327024 | 55.4504 | 0.171875 | 55.4504 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1805 | Level: Level 1 | -500 | Level : Level 1
635853 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1811 | Level: Level 1 | -500 | Level : Level 1
635866 | TOF Footing | 0.109375 | 88.635 | 0.0677083 | 91.365 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1817 | Level: Level 1 | -200 | Level : Level 1
635967 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1833 | Level: Level 1 | 232.932 | Level : Level 1
635998 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1839 | Level: Level 1 | -300 | Level : Level 1
636052 | TOF Footing | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1846 | Level: Level 1 | -500 | Level : Level 1
636096 | TOF Footing | 0.330808 | 54.9092 | 0.171875 | 54.9092 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1854 | Level: Level 1 | -500 | Level : Level 1
636340 | TOF Footing | 0.314353 | 44.9997 | 0.130208 | 135 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1873 | Level: Level 1 | -500 | Level : Level 1
636418 | TOF Footing | 0.250128 | 55 | 0.130208 | 55 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1881 | Level: Level 1 | -500 | Level : Level 1
636557 | TOF Footing | 0.314351 | 45 | 0.130208 | 135 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1903 | Level: Level 1 | -500 | Level : Level 1
636666 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1918 | Level: Level 1 | -500 | Level : Level 1
636677 | TOF Footing | 0.41543 | 44.9525 | 0.171875 | 44.9525 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1927 | Level: Level 1 | -500 | Level : Level 1
636772 | TOF Footing | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1938 | Level: Level 1 | -500 | Level : Level 1
636814 | TOF Footing | 0.297698 | 59.9997 | 0.171875 | 120 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1945 | Level: Level 1 | -500 | Level : Level 1
636882 | TOF Footing | 0.415411 | 44.9543 | 0.171875 | 44.9543 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1955 | Level: Level 1 | -500 | Level : Level 1
637031 | TOF Footing | 0.414943 | 45 | 0.171875 | 135 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1976 | Level: Level 1 | -500 | Level : Level 1
637194 | TOF Footing | 0.414943 | 45 | 0.171875 | 135 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1984 | Level: Level 1 | -501.123 | Level : Level 1
637266 | TOF Footing | 0.335637 | 54.2327 | 0.171875 | 54.2327 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 1998 | Level: Level 1 | -501.123 | Level : Level 1
637393 | TOF Footing | 0.413219 | 45.1689 | 0.171875 | 45.1689 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2003 | Level: Level 1 | -501.123 | Level : Level 1
637425 | TOF Footing | 0.171875 | 90 | 0.130208 | 90 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2012 | Level: Level 1 | -501.123 | Level : Level 1
637526 | TOF Footing | 0.213542 | 89.7201 | 0.171875 | 89.7201 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2035 | Level: Level 1 | -501.123 | Level : Level 1
637571 | TOF Footing | 0.414943 | 45 | 0.171875 | 135 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2042 | Level: Level 1 | -501.123 | Level : Level 1
637627 | TOF Footing | 0.320704 | 56.3764 | 0.171875 | 123.624 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2051 | Level: Level 1 | -501.123 | Level : Level 1
637708 | TOF Footing | 0.414943 | 45 | 0.171875 | 135 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2071 | Level: Level 1 | -501.123 | Level : Level 1
637809 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2083 | Level: Level 1 | 0 | Level : Level 1
637863 | TOF Footing | 0.414943 | 45 | 0.171875 | 135 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2088 | Level: Level 1 | -501.123 | Level : Level 1
637907 | TOF Footing | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2091 | Level: Level 1 | -501.123 | Level : Level 1
638093 | TOF Footing | 0.213542 | 89.9999 | 0.171875 | 89.9999 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2098 | Level: Level 1 | -501.123 | Level : Level 1
638170 | TOF Footing | 0.213542 | 89.9997 | 0.171875 | 90.0003 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2117 | Level: Level 1 | -501.123 | Level : Level 1
638349 | TOF Footing | 0.414943 | 45 | 0.171875 | 135 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2124 | Level: Level 1 | -501.123 | Level : Level 1
639014 | TOF Footing | 0.159415 | 58.0969 | 0.0885417 | 121.903 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2147 | Level: Level 1 | -501.123 | Level : Level 1
639184 | Level 1 | 0.171875 | 90 | 0.130208 | 90 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2176 | Level: Level 1 | 400 | Level : Level 1
639216 | TOF Footing | 0.308781 | 32 | 0.0885417 | 148 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2182 | Level: Level 1 | -501.123 | Level : Level 1
639340 | TOF Footing | 0.214271 | 44.9031 | 0.0885417 | 44.9031 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2200 | Level: Level 1 | -501.123 | Level : Level 1
639405 | TOF Footing | 0.313434 | 57.4773 | 0.171875 | 57.4773 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2207 | Level: Level 1 | -501.123 | Level : Level 1
639470 | TOF Footing | 0.414943 | 45 | 0.171875 | 135 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2225 | Level: Level 1 | -501.123 | Level : Level 1
639538 | TOF Footing | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2232 | Level: Level 1 | -501.123 | Level : Level 1
639590 | TOF Footing | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2238 | Level: Level 1 | -501.123 | Level : Level 1
639647 | TOF Footing | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2243 | Level: Level 1 | -501.123 | Level : Level 1
639808 | TOF Footing | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2273 | Level: Level 1 | -501.123 | Level : Level 1
639860 | TOF Footing | 0.414943 | 45 | 0.171875 | 135 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2284 | Level: Level 1 | -501.123 | Level : Level 1
639934 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2295 | Level: Level 1 | 0 | Level : Level 1
640020 | TOF Footing | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2316 | Level: Level 1 | -500 | Level : Level 1
640083 | TOF Footing | 0.325728 | 55.638 | 0.171875 | 124.362 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2326 | Level: Level 1 | -500 | Level : Level 1
640317 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2347 | Level: Level 1 | -500 | Level : Level 1
640413 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2365 | Level: Level 1 | -500 | Level : Level 1
640479 | TOF Footing | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2370 | Level: Level 1 | -500 | Level : Level 1
640546 | TOF Footing | 0.414943 | 45 | 0.171875 | 135 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2382 | Level: Level 1 | -500 | Level : Level 1
640626 | TOF Footing | 0.413999 | 45.0924 | 0.171875 | 134.908 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2402 | Level: Level 1 | -500 | Level : Level 1
640679 | TOF Footing | 0.414943 | 45 | 0.171875 | 135 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2409 | Level: Level 1 | -500 | Level : Level 1
641151 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2417 | Level: Level 1 | -500 | Level : Level 1
641158 | TOF Footing | 0.163462 | 45 | 0.0677083 | 45 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2423 | Level: Level 1 | -300 | Level : Level 1
641193 | TOF Footing | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2426 | Level: Level 1 | -500 | Level : Level 1
641235 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2435 | Level: Level 1 | -500 | Level : Level 1
641242 | TOF Footing | 0.109375 | 68 | 0.0677083 | 112 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2441 | Level: Level 1 | -300 | Level : Level 1
641261 | TOF Footing | 0.171875 | 90 | 0.130208 | 90 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2447 | Level: Level 1 | -500 | Level : Level 1
641268 | TOF Footing | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2453 | Level: Level 1 | -300 | Level : Level 1
641362 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2458 | Level: Level 2 | -5070 | Level : Level 2
641599 | TOF Footing | 0.314351 | 45 | 0.130208 | 45 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2475 | Level: Level 1 | -500 | Level : Level 1
641635 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2486 | Level: Level 1 | -500 | Level : Level 1
641642 | TOF Footing | 0.163462 | 45 | 0.0677083 | 135 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2492 | Level: Level 1 | -300 | Level : Level 1
641977 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2522 | Level: Level 1 | -500 | Level : Level 1
642085 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2551 | Level: Level 1 | -500 | Level : Level 1
642108 | TOF Footing | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2557 | Level: Level 1 | -300 | Level : Level 1
642170 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2561 | Level: Level 1 | -500 | Level : Level 1
642335 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2587 | Level: Level 1 | -500 | Level : Level 1
642459 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2603 | Level: Level 1 | -500 | Level : Level 1
642608 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2616 | Level: Level 1 | 3100 | Level : Level 1
642629 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2617 | Level: Level 1 | -500 | Level : Level 1
642724 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2625 | Level: Level 1 | -500 | Level : Level 1
642803 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2651 | Level: Level 1 | 0 | Level : Level 1
643063 | TOF Footing | 0.414943 | 45 | 0.171875 | 135 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2669 | Level: Level 1 | -500 | Level : Level 1
643206 | TOF Footing | 0.213758 | 45 | 0.0885417 | 45 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2697 | Level: Level 1 | -500 | Level : Level 1
643231 | TOF Footing | 0.213758 | 45 | 0.0885417 | 135 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2702 | Level: Level 1 | -500 | Level : Level 1
643371 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2716 | Level: Level 1 | -500 | Level : Level 1
643526 | Level 1 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2735 | Level: Level 1 | 2900 | Level : Level 1
643559 | TOF Footing | 0.213758 | 45 | 0.0885417 | 45 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2738 | Level: Level 1 | -500 | Level : Level 1
643587 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2741 | Level: Level 1 | -500 | Level : Level 1
643618 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2750 | Level: Level 1 | -500 | Level : Level 1
643626 | TOF Footing | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2756 | Level: Level 1 | -300 | Level : Level 1
643712 | TOF Footing | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2768 | Level: Level 1 | -300 | Level : Level 1
644021 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2788 | Level: Level 1 | -500 | Level : Level 1
644183 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2814 | Level: Level 1 | -500 | Level : Level 1
644190 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2820 | Level: Level 1 | -300 | Level : Level 1
644203 | TOF Footing | 0.532656 | 35.7673 | 0.171875 | 35.7673 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2824 | Level: Level 1 | -501.123 | Level : Level 1
644755 | Level 1 | 0.171875 | 90 | 0.130208 | 90 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2847 | Level: Level 1 | 300 | Level : Level 1
644762 | Level 1 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2853 | Level: Level 1 | 3000 | Level : Level 1
644781 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2856 | Level: Level 1 | -501.123 | Level : Level 1
644845 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2860 | Level: Level 1 | -501.123 | Level : Level 1
644908 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2866 | Level: Level 1 | 232.932 | Level : Level 1
644936 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2876 | Level: Level 1 | -501.123 | Level : Level 1
644956 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2881 | Level: Level 1 | 600 | Level : Level 1
645354 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2895 | Level: Level 1 | -501.123 | Level : Level 1
645541 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2916 | Level: Level 1 | -501.123 | Level : Level 1
645705 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2941 | Level: Level 1 | -501.123 | Level : Level 1
645813 | TOF Footing | 0.171875 | 90 | 0.130208 | 90 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2958 | Level: Level 1 | -500 | Level : Level 1
645854 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2977 | Level: Level 1 | -300 | Level : Level 1
645866 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2980 | Level: Level 1 | -500 | Level : Level 1
645923 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2990 | Level: Level 1 | -300 | Level : Level 1
645953 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 2993 | Level: Level 1 | -500 | Level : Level 1
646046 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 3001 | Level: Level 1 | -500 | Level : Level 1
646067 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 3006 | Level: Level 1 | -300 | Level : Level 1
646095 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 3007 | Level: Level 1 | -500 | Level : Level 1
646199 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 3037 | Level: Level 1 | -501.123 | Level : Level 1
646269 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 3047 | Level: Level 1 | -501.123 | Level : Level 1
646276 | TOF Footing | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 3053 | Level: Level 1 | -300 | Level : Level 1
646357 | TOF Footing | 0.305947 | 32.2811 | 0.0885417 | 32.2811 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 3056 | Level: Level 1 | -501.123 | Level : Level 1
646384 | TOF Footing | 0.130208 | 89.5925 | 0.0885417 | 89.5925 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 3062 | Level: Level 1 | -501.123 | Level : Level 1
646406 | TOF Footing | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 3070 | Level: Level 1 | -300 | Level : Level 1
646429 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 3078 | Level: Level 1 | -501.123 | Level : Level 1
646584 | TOF Footing | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 3107 | Level: Level 1 | -300 | Level : Level 1
646650 | TOF Footing | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 3114 | Level: Level 1 | -300 | Level : Level 1
646724 | TOF Footing | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 5 | Sanitary 1 | 3117 | Level: Level 1 | -501.123 | Level : Level 1
646758 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3124 | Level: Level 1 | -500 | Level : Level 1
646859 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3132 | Level: Level 1 | 0 | Level : Level 1
647036 | TOF Footing | 0.414943 | 45 | 0.171875 | 135 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3148 | Level: Level 1 | -501.123 | Level : Level 1
647415 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3182 | Level: Level 1 | 2900 | Level : Level 1
647481 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3194 | Level: Level 1 | -500 | Level : Level 1
647519 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3201 | Level: Level 1 | -500 | Level : Level 1
647573 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3205 | Level: Level 1 | 232.932 | Level : Level 1
647706 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3222 | Level: Level 1 | 0 | Level : Level 1
647786 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3233 | Level: Level 1 | 1000 | Level : Level 1
648098 | Level 1 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3250 | Level: Level 1 | 0 | Level : Level 1
648146 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3256 | Level: Level 1 | 0 | Level : Level 1
648291 | Level 1 | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3267 | Level: Level 1 | 0 | Level : Level 1
648403 | Level 1 | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3273 | Level: Level 1 | 0 | Level : Level 1
653819 | Level 1 | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3297 | Level: Level 2 | -411 | Level : Level 2
653952 | Level 1 | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3304 | Level: Level 2 | -411 | Level : Level 2
654020 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3314 | Level: Level 2 | -411 | Level : Level 2
654059 | Level 2 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3320 | Level: Level 2 | 232.932 | Level : Level 2
654324 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3348 | Level: Level 2 | -411 | Level : Level 2
654458 | TOF Footing | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3357 | Level: Level 1 | -500 | Level : Level 1
654514 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3362 | Level: Level 2 | -411 | Level : Level 2
654592 | Level 1 | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3363 | Level: Level 2 | -411 | Level : Level 2
655124 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3403 | Level: Level 1 | 0 | Level : Level 1
655429 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3434 | Level: Level 2 | -411 | Level : Level 2
655494 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3438 | Level: Level 2 | -411 | Level : Level 2
655501 | Level 1 | 0.213758 | 45 | 0.0885417 | 45 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3444 | Level: Level 2 | -200 | Level : Level 2
655520 | Level 1 | 0.15548 | 59.3208 | 0.0885417 | 59.3208 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3454 | Level: Level 2 | -200 | Level : Level 2
655526 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3458 | Level: Level 2 | -200 | Level : Level 2
655599 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3462 | Level: Level 2 | -411 | Level : Level 2
655606 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3468 | Level: Level 2 | -200 | Level : Level 2
655688 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3474 | Level: Level 1 | -500 | Level : Level 1
655913 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3485 | Level: Level 2 | -1400 | Level : Level 2
655985 | Level 2 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3500 | Level: Level 2 | 232.932 | Level : Level 2
656392 | Level 1 | 0.171875 | 90 | 0.130208 | 90 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3528 | Level: Level 1 | 400 | Level : Level 1
656448 | TOF Footing | 0.171875 | 90 | 0.130208 | 90 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3534 | Level: Level 1 | -500 | Level : Level 1
656798 | TOF Footing | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3568 | Level: Level 1 | -300 | Level : Level 1
656945 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3579 | Level: Level 1 | 0 | Level : Level 1
657191 | Level 1 | 0.171875 | 90 | 0.130208 | 90 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3610 | Level: Level 2 | -1682.2 | Level : Level 2
657991 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3649 | Level: Level 2 | -1688.2 | Level : Level 2
657996 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3653 | Level: Level 2 | -1400 | Level : Level 2
658032 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3656 | Level: Level 1 | -500 | Level : Level 1
658064 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3658 | Level: Level 2 | -1688.2 | Level : Level 2
658207 | Level 1 | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3668 | Level: Level 2 | -1688.2 | Level : Level 2
658324 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3679 | Level: Level 2 | -1688.2 | Level : Level 2
658386 | Level 1 | 0.414943 | 45 | 0.171875 | 135 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3689 | Level: Level 2 | -1688.2 | Level : Level 2
658518 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3709 | Level: Level 1 | 600 | Level : Level 1
658540 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3712 | Level: Level 2 | -1688.2 | Level : Level 2
658564 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3719 | Level: Level 2 | -1400 | Level : Level 2
658582 | Level 1 | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3720 | Level: Level 2 | -1688.2 | Level : Level 2
659065 | Level 1 | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3768 | Level: Level 2 | -1688.2 | Level : Level 2
659152 | Level 1 | 0.414943 | 45 | 0.171875 | 135 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3781 | Level: Level 2 | -1688.2 | Level : Level 2
659242 | Level 1 | 0.314351 | 45 | 0.130208 | 135 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3794 | Level: Level 2 | -1688.2 | Level : Level 2
659884 | Level 2 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3854 | Level: Level 2 | 200 | Level : Level 2
660103 | Level 1 | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3885 | Level: Level 2 | -1688.2 | Level : Level 2
660278 | Level 1 | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3900 | Level: Level 2 | -1688.2 | Level : Level 2
660382 | Level 1 | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3913 | Level: Level 2 | -1688.2 | Level : Level 2
660648 | Level 1 | 0.414943 | 45 | 0.171875 | 135 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3934 | Level: Level 2 | -1688.2 | Level : Level 2
660721 | Level 1 | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3952 | Level: Level 2 | -1688.2 | Level : Level 2
660941 | Level 1 | 0.314351 | 45 | 0.130208 | 45 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 3990 | Level: Level 2 | -1688.2 | Level : Level 2
661049 | Level 2 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4005 | Level: Level 2 | 200 | Level : Level 2
661096 | Level 2 | 0.171875 | 90 | 0.130208 | 90 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4009 | Level: Level 2 | 200 | Level : Level 2
661110 | Level 2 | 0.171875 | 90 | 0.130208 | 90 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4010 | Level: Level 2 | 500 | Level : Level 2
661154 | Level 1 | 0.314351 | 45 | 0.130208 | 135 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4023 | Level: Level 2 | -1688.2 | Level : Level 2
661268 | Level 2 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4040 | Level: Level 2 | 200 | Level : Level 2
661305 | Level 2 | 0.171875 | 90 | 0.130208 | 90 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4046 | Level: Level 2 | 200 | Level : Level 2
661439 | Level 1 | 0.171875 | 90 | 0.130208 | 90 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4056 | Level: Level 2 | -1688.2 | Level : Level 2
661636 | Level 1 | 0.171875 | 90 | 0.130208 | 90 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4085 | Level: Level 2 | -1688.2 | Level : Level 2
661864 | Level 1 | 0.314351 | 45 | 0.130208 | 45 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4116 | Level: Level 2 | -1688.2 | Level : Level 2
661949 | Level 1 | 0.314351 | 45 | 0.130208 | 45 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4129 | Level: Level 2 | -1688.2 | Level : Level 2
662071 | Level 1 | 0.314351 | 45 | 0.130208 | 135 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4147 | Level: Level 2 | -1688.2 | Level : Level 2
662124 | Level 1 | 0.314351 | 45 | 0.130208 | 135 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4161 | Level: Level 2 | -1688.2 | Level : Level 2
662264 | TOF Footing | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4183 | Level: Level 1 | -500 | Level : Level 1
662329 | Level 2 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4193 | Level: Level 2 | 200 | Level : Level 2
662455 | Level 2 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4210 | Level: Level 2 | 200 | Level : Level 2
662519 | Level 1 | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4215 | Level: Level 2 | -1688.2 | Level : Level 2
662557 | TOF Footing | 0.213542 | 90 | 0.171875 | 90 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4221 | Level: Level 1 | -500 | Level : Level 1
662596 | Level 2 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4227 | Level: Level 2 | 200 | Level : Level 2
662633 | Level 1 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4229 | Level: Level 2 | -1688.2 | Level : Level 2
662652 | Level 2 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4233 | Level: Level 2 | 200 | Level : Level 2
662671 | Level 2 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4237 | Level: Level 2 | 200 | Level : Level 2
662688 | Level 2 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4240 | Level: Level 2 | 500 | Level : Level 2
662849 | TOF Footing | 0.0989583 | 90 | 0.0572917 | 90 | 0.0989583 | 0.114583 | 32 mmø-32 mmø-32 mmø | 0.104987 | 0.0458333 | 0.0524934 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4251 | Level: Level 1 | -300 | Level : Level 1
663133 | Level 2 | 0.171875 | 90 | 0.130208 | 90 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4300 | Level: Level 2 | 200 | Level : Level 2
664142 | Level 1 | 0.414943 | 45 | 0.171875 | 135 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4362 | Level: Level 2 | -1688.2 | Level : Level 2
664262 | Level 1 | 0.109375 | 90 | 0.0677083 | 90 | 0.109375 | 0.135417 | 40 mmø-40 mmø-40 mmø | 0.131234 | 0.0541667 | 0.0656168 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4379 | Level: Level 1 | 3170 | Level : Level 1
664313 | Level 1 | 0.171875 | 90 | 0.130208 | 90 | 0.171875 | 0.260417 | 80 mmø-80 mmø-80 mmø | 0.262467 | 0.104167 | 0.131234 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4397 | Level: Level 2 | -1688.2 | Level : Level 2
664332 | Level 1 | 0.414943 | 45 | 0.171875 | 45 | 0.213542 | 0.34375 | 100 mmø-100 mmø-100 mmø | 0.328084 | 0.1375 | 0.164042 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4407 | Level: Level 2 | -1688.2 | Level : Level 2
664488 | Level 2 | 0.130208 | 90 | 0.0885417 | 90 | 0.130208 | 0.177083 | 50 mmø-50 mmø-50 mmø | 0.164042 | 0.0708333 | 0.082021 | Piping System: Sanitary 1 | Sanitary | 1 | Sanitary 1 | 4438 | Level: Level 2 | 200 | Level : Level 2
